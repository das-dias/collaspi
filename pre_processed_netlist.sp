*SPICE "1.0"
*DESIGN "tv_dynamic_ls"
*DATE "Wed Jun 11 11:34:35 2025"
*VENDOR "Mentor Graphics Corp."
*PROGRAM "Calibre xRC"
*VERSION "v2023.4_17.10"
*DESIGN_FLOW "extraction"
*DIVIDER /
*DELIMITER :
*BUS_DELIMITER []
* CIRCUIT TEMPERATURE 25C
* NOMINAL TEMPERATURE 25C

C123 enableb:96 0 0.0264982f
C124 enableb:89 0 0.0136054f
C125 enableb:84 0 0.0329044f
C126 enableb:77 0 0.00166428f
C127 enableb:73 0 0.00840266f
C128 enableb:68 0 0.0127654f
C129 enableb:63 0 0.0018805f
C130 enableb:60 0 7.59813e-19
C131 enableb:50 0 0.0248516f
C132 enableb:48 0 0.00793393f
C133 enableb:44 0 0.00648921f
C134 enableb:36 0 0.00241692f
C135 enableb:30 0 0.0352205f
C136 enableb:26 0 0.0107209f
C137 enableb:21 0 0.0174342f
C138 enableb:17 0 0.00944885f
C139 enableb:14 0 0.00880309f
C140 enableb:10 0 0.00794511f
C141 enableb:8 0 0.00911917f
C142 enableb:5 0 0.00765983f
C143 enableb:1 0 0.00748484f
R144 enableb:98 enableb:102 0.59375
R145 enableb:96 enableb:102 1.6625
R146 enableb:91 enableb:94 1.0625
R147 enableb:89 enableb:94 2.975
R148 enableb:86 enableb:87 3.05089
R149 enableb:83 enableb:87 10.6739
R150 enableb:83 enableb:84 1.46292
R151 enableb:81 enableb:84 0.52099
R152 enableb:77 enableb:81 0.241545
R153 enableb:77 enableb:79 0.0764722
R154 enableb:73 enableb:86 8
R155 enableb:68 enableb:83 8
R156 enableb:63 enableb:79 8
R157 enableb:56 enableb:59 0.315999
R158 enableb:54 enableb:55 2.06798
R159 enableb:53 enableb:54 1.24963
R160 enableb:52 enableb:53 0.899121
R161 enableb:51 enableb:60 0.180126
R162 enableb:51 enableb:52 0.220081
R163 enableb:50 enableb:56 0.237673
R164 enableb:50 enableb:55 0.210666
R165 enableb:48 enableb:98 90
R166 enableb:46 enableb:61 0.181184
R167 enableb:46 enableb:48 0.554178
R168 enableb:44 enableb:98 30
R169 enableb:42 enableb:61 0.181184
R170 enableb:42 enableb:44 0.114657
R171 enableb:38 enableb:60 0.0468115
R172 enableb:38 enableb:41 0.315999
R173 enableb:36 enableb:91 40
R174 enableb:34 enableb:36 0.191096
R175 enableb:32 enableb:73 8
R176 enableb:30 enableb:61 0.0470866
R177 enableb:30 enableb:32 1.66351
R178 enableb:28 enableb:68 8
R179 enableb:26 enableb:34 0.239069
R180 enableb:26 enableb:28 0.344174
R181 enableb:23 enableb:63 8
R182 enableb:23 enableb:25 0.684664
R183 enableb:21 enableb:60 0.180126
R184 enableb:21 enableb:25 0.953685
R185 enableb:14 enableb:59 0.19916
R186 enableb:14 enableb:17 133.333
R187 enableb:12 enableb:17 137.532
R188 enableb:10 enableb:12 137.532
R189 enableb:5 enableb:41 0.19916
R190 enableb:5 enableb:8 133.333
R191 enableb:3 enableb:8 137.532
R192 enableb:1 enableb:3 137.532
** enableb 1.12774e-15 *
C1 vssd:11 MM6:g 0.0155342f
C2 vssd:11 enableb:14 7.55916e-19
C3 vssd:70 enableb:5 0.00183289f
C4 vssd:70 enableb:21 0.00325146f
C5 vssd:70 enableb:26 0.003912f
C6 vssd:70 enableb:36 8.43403e-19
C7 vssd:70 enableb:63 0.0018103f
C8 vssd:70 enableb:68 0.00290913f
C9 vssd:70 enableb:84 6.99772e-19
C10 vssd:82 enableb:30 0.0033617f
C11 vssd:82 enableb:44 4.67899e-19
C12 vssd:82 enableb:48 4.72523e-19
C13 vssd:82 enableb:73 0.00250752f
C14 vssd:113 enableb:5 3.80499e-19
C15 vssd:113 enableb:21 0.00395098f
C16 vssd:117 enableb:21 7.33742e-19
C17 vssd:117 enableb:26 0.00467771f
C18 vssd:117 enableb:68 6.71794e-19
C19 vssd:117 enableb:84 0.00566547f
C20 vssd:124 enableb:26 2.40612e-19
C21 vssd:124 enableb:68 5.9668e-19
C22 vssd:140 enableb:21 0.00225188f
C23 vssd:144 MM14:g 0.00130531f
C24 vssd:144 enableb:50 4.24523e-19
C25 vssd:175 MM6:g 5.00531e-19
C26 vssd:175 enableb:14 9.70245e-19
C27 vssd:183 MM6:g 0.00148292f
C28 vssd:183 enableb:50 6.8581e-19
C29 MM13:s MM14:g 0.0155342f
C30 MM13:s enableb:5 0.00101005f
C31 vssd:223 XI0/MM2:d 0.015476f
C32 vssd:326 MM14:g 0.00101756f
C33 vssd:326 MM6:g 6.05283e-19
C232 vssd:326 0 0.00248834f
C233 vssd:313 0 0.00880405f
C234 vssd:246 0 1.51295e-20
C235 vssd:223 0 0.00366891f
C236 vssd:211 0 8.35052e-20
C237 vssd:197 0 0.00128137f
C238 vssd:195 0 0.00128137f
C239 vssd:194 0 0.00128137f
C240 vssd:193 0 0.00128137f
C241 vssd:191 0 2.19327e-19
C242 vssd:189 0 0.00962328f
C243 vssd:188 0 0.00961107f
C244 vssd:186 0 1.10945f
C245 vssd:183 0 0.00612086f
C246 vssd:175 0 0.0139427f
C247 vssd:173 0 0.0037305f
C248 vssd:166 0 0.00504787f
C249 vssd:164 0 0.00391667f
C250 vssd:155 0 0.00488102f
C251 vssd:153 0 0.00371646f
C252 vssd:146 0 0.00477824f
C253 vssd:144 0 0.00605537f
C254 vssd:140 0 0.0114052f
C255 vssd:124 0 0.0118644f
C256 vssd:120 0 2.26832f
C257 vssd:117 0 0.0268697f
C258 vssd:113 0 0.0412247f
C259 vssd:112 0 0.0769779f
C260 vssd:111 0 2.31447f
C261 vssd:82 0 0.462615f
C262 vssd:80 0 0.0769779f
C263 vssd:70 0 0.0967648f
C264 vssd:58 0 0.229591f
C265 vssd:11 0 8.35052e-20
R266 vssd:324 vssd:326 26.125
R267 vssd:316 vssd:319 40.755
R268 vssd:311 vssd:313 26.125
R269 vssd:309 vssd:311 39.1875
R270 vssd:301 vssd:304 39.71
R271 vssd:296 vssd:298 18.1133
R272 vssd:294 vssd:296 27.17
R273 vssd:292 vssd:294 27.17
R274 vssd:290 vssd:292 27.17
R275 vssd:288 vssd:290 27.17
R276 vssd:286 vssd:288 27.17
R277 vssd:284 vssd:286 27.17
R278 vssd:282 vssd:284 26.4733
R279 vssd:280 vssd:282 26.125
R280 vssd:278 vssd:280 26.125
R281 vssd:276 vssd:278 26.125
R282 vssd:274 vssd:276 26.125
R283 vssd:267 vssd:269 26.125
R284 vssd:265 vssd:267 26.125
R285 vssd:263 vssd:265 26.125
R286 vssd:261 vssd:263 26.125
R287 vssd:259 vssd:261 26.125
R288 vssd:257 vssd:259 26.125
R289 vssd:255 vssd:257 26.125
R290 vssd:253 vssd:255 26.125
R291 vssd:251 vssd:253 26.125
R292 vssd:249 vssd:251 26.125
R293 vssd:246 vssd:249 26.125
R294 vssd:220 vssd:223 1.0625
R295 vssd:218 vssd:242 4.0375
R296 vssd:217 vssd:238 4.0375
R297 vssd:216 vssd:238 4.0375
R298 vssd:215 vssd:234 4.0375
R299 vssd:214 vssd:234 4.0375
R300 vssd:213 vssd:230 4.0375
R301 vssd:212 vssd:230 4.0375
R302 vssd:211 vssd:227 4.0375
R303 vssd:210 vssd:220 2.975
R304 vssd:197 vssd:324 30
R305 vssd:193 vssd:316 30
R306 vssd:188 vssd:257 30
R307 vssd:185 vssd:186 6.00411
R308 vssd:181 vssd:183 0.816201
R309 vssd:179 vssd:180 0.0871931
R310 vssd:178 vssd:326 45
R311 vssd:178 vssd:180 0.123546
R312 vssd:176 vssd:197 0.0497721
R313 vssd:176 vssd:179 0.131783
R314 vssd:175 vssd:181 0.362155
R315 vssd:175 vssd:178 0.00823641
R316 vssd:172 vssd:238 40
R317 vssd:172 vssd:173 0.533535
R318 vssd:170 vssd:197 0.231753
R319 vssd:170 vssd:173 0.823885
R320 vssd:168 vssd:169 0.0871931
R321 vssd:167 vssd:195 0.0497721
R322 vssd:167 vssd:168 0.131783
R323 vssd:166 vssd:197 0.0497721
R324 vssd:166 vssd:169 0.131783
R325 vssd:163 vssd:234 40
R326 vssd:163 vssd:164 0.533535
R327 vssd:161 vssd:195 0.231753
R328 vssd:161 vssd:164 0.823885
R329 vssd:158 vssd:319 30
R330 vssd:158 vssd:160 0.0697545
R331 vssd:158 vssd:159 0.0174386
R332 vssd:156 vssd:194 0.0497721
R333 vssd:156 vssd:159 0.131783
R334 vssd:155 vssd:195 0.0497721
R335 vssd:155 vssd:160 0.131783
R336 vssd:152 vssd:230 40
R337 vssd:152 vssd:153 0.533535
R338 vssd:150 vssd:194 0.231753
R339 vssd:150 vssd:153 0.823885
R340 vssd:148 vssd:149 0.0871931
R341 vssd:147 vssd:193 0.0497721
R342 vssd:147 vssd:148 0.131783
R343 vssd:146 vssd:194 0.0497721
R344 vssd:146 vssd:149 0.131783
R345 vssd:142 vssd:193 0.231753
R346 vssd:142 vssd:144 0.816201
R347 vssd:140 vssd:313 90
R348 vssd:137 vssd:311 30
R349 vssd:137 vssd:140 0.445224
R350 vssd:137 vssd:138 0.115758
R351 vssd:135 vssd:309 30
R352 vssd:135 vssd:138 0.61392
R353 vssd:132 vssd:304 30
R354 vssd:132 vssd:135 0.742645
R355 vssd:132 vssd:133 0.544606
R356 vssd:130 vssd:301 30
R357 vssd:130 vssd:133 0.186994
R358 vssd:128 vssd:191 0.0497721
R359 vssd:128 vssd:130 0.186994
R360 vssd:126 vssd:127 0.645368
R361 vssd:124 vssd:223 40
R362 vssd:124 vssd:126 0.689836
R363 vssd:122 vssd:191 0.231753
R364 vssd:122 vssd:127 0.401536
R365 vssd:120 vssd:186 0.233952
R366 vssd:120 vssd:121 12.1801
R367 vssd:118 vssd:189 0.185778
R368 vssd:118 vssd:119 0.733041
R369 vssd:117 vssd:191 0.0497721
R370 vssd:117 vssd:119 0.169185
R371 vssd:115 vssd:116 0.0871931
R372 vssd:114 vssd:188 0.185778
R373 vssd:114 vssd:115 1.10368
R374 vssd:113 vssd:193 0.0497721
R375 vssd:113 vssd:116 0.131783
R376 vssd:111 vssd:185 0.233952
R377 vssd:111 vssd:112 12.1801
R378 vssd:110 vssd:298 45
R379 vssd:108 vssd:296 30
R380 vssd:108 vssd:110 0.144143
R381 vssd:106 vssd:294 30
R382 vssd:106 vssd:108 0.216215
R383 vssd:104 vssd:292 30
R384 vssd:104 vssd:106 0.216215
R385 vssd:102 vssd:290 30
R386 vssd:102 vssd:104 0.216215
R387 vssd:100 vssd:288 30
R388 vssd:100 vssd:102 0.216215
R389 vssd:98 vssd:286 30
R390 vssd:98 vssd:100 0.216215
R391 vssd:96 vssd:284 30
R392 vssd:96 vssd:98 0.216215
R393 vssd:94 vssd:282 30
R394 vssd:94 vssd:96 0.210671
R395 vssd:92 vssd:280 30
R396 vssd:92 vssd:94 0.207899
R397 vssd:90 vssd:278 30
R398 vssd:90 vssd:92 0.207899
R399 vssd:88 vssd:276 30
R400 vssd:88 vssd:90 0.207899
R401 vssd:86 vssd:274 30
R402 vssd:86 vssd:88 0.207899
R403 vssd:84 vssd:269 30
R404 vssd:84 vssd:86 0.207899
R405 vssd:82 vssd:267 30
R406 vssd:82 vssd:84 0.207899
R407 vssd:80 vssd:110 0.496185
R408 vssd:79 vssd:189 0.0661015
R409 vssd:79 vssd:82 0.0415797
R410 vssd:78 vssd:265 30
R411 vssd:75 vssd:263 30
R412 vssd:75 vssd:78 0.207899
R413 vssd:75 vssd:76 0.177407
R414 vssd:72 vssd:261 30
R415 vssd:72 vssd:76 0.0309935
R416 vssd:72 vssd:73 0.00845278
R417 vssd:70 vssd:259 30
R418 vssd:70 vssd:73 0.199583
R419 vssd:68 vssd:189 0.0661015
R420 vssd:68 vssd:78 0.0554396
R421 vssd:67 vssd:188 0.0661015
R422 vssd:67 vssd:70 0.194039
R423 vssd:66 vssd:255 30
R424 vssd:64 vssd:253 30
R425 vssd:64 vssd:66 0.207899
R426 vssd:62 vssd:251 30
R427 vssd:62 vssd:64 0.207899
R428 vssd:60 vssd:249 30
R429 vssd:60 vssd:62 0.207899
R430 vssd:58 vssd:246 30
R431 vssd:58 vssd:60 0.207899
R432 vssd:56 vssd:188 0.0661015
R433 vssd:56 vssd:66 0.110879
R434 vssd:55 vssd:112 0.233952
R435 vssd:55 vssd:58 0.529449
R436 vssd:54 vssd:80 0.116976
R437 vssd:54 vssd:121 0.116976
R438 vssd:11 vssd:242 0.0085
R439 vssd:10 vssd:11 4.029
R440 vssd:9 vssd:183 0.533535
R441 vssd:9 vssd:11 40
R442 vssd:5 vssd:227 0.0085
R443 vssd:4 vssd:5 4.029
R444 vssd:3 vssd:144 0.533535
R445 vssd:3 vssd:5 40
R446 vssd:2 vssd:324 27.6925
R447 vssd:2 vssd:319 12.54
R448 vssd:2 vssd:309 13.585
R449 vssd:2 vssd:304 25.6025
R450 vssd:2 vssd:274 0.5225
R451 vssd:2 vssd:269 25.6025
** vssd 9.44034e-15 *
C34 vddd:248 enableb:84 0.00127869f
C35 vddd:296 enableb:14 0.00249382f
C36 vddd:589 enableb:30 6.0062e-19
C37 vddd:589 enableb:44 0.00246747f
C38 vddd:589 enableb:84 0.00133937f
C39 vddd:589 XI0/MM1:d 0.00111415f
C40 vddd:646 enableb:44 3.30757e-19
C41 vddd:646 XI0/MM1:d 0.00124668f
C42 MM9:s XI0/MM1:d 0.0314026f
C43 vddd:248 vssd:82 0.00111557f
C44 vddd:293 vssd:111 0.382323f
C45 vddd:296 vssd:140 0.00149775f
C46 vddd:296 vssd:175 0.00176813f
C47 vddd:296 vssd:183 0.00153208f
C48 vddd:324 vssd:120 0.485293f
C49 vddd:541 vssd:186 0.179556f
C50 vddd:589 vssd:82 8.91023e-19
C303 vddd:1276 0 0.0265102f
C304 vddd:1256 0 4.30969e-20
C305 vddd:1254 0 4.30969e-20
C306 vddd:1249 0 7.59902e-21
C307 vddd:1104 0 3.29095e-19
C308 vddd:1103 0 3.29095e-19
C309 vddd:930 0 3.29095e-19
C310 vddd:757 0 3.29095e-19
C311 vddd:700 0 6.58191e-19
C312 vddd:649 0 3.29095e-19
C313 vddd:648 0 3.29095e-19
C314 vddd:646 0 0.00121022f
C315 vddd:632 0 0.00186373f
C316 vddd:628 0 0.00995729f
C317 vddd:622 0 0.011953f
C318 vddd:616 0 0.0117375f
C319 vddd:610 0 0.0684947f
C320 vddd:597 0 0.00638427f
C321 vddd:592 0 3.14497e-19
C322 vddd:591 0 3.14497e-19
C323 vddd:590 0 3.14497e-19
C324 vddd:589 0 0.00344534f
C325 vddd:544 0 0.599827f
C326 vddd:542 0 0.0363597f
C327 vddd:541 0 0.0368414f
C328 vddd:536 0 9.02688e-19
C329 vddd:530 0 0.00108436f
C330 vddd:437 0 1.18018f
C331 vddd:345 0 1.20813f
C332 vddd:326 0 0.256611f
C333 vddd:324 0 0.049566f
C334 vddd:296 0 0.395222f
C335 vddd:293 0 0.0500477f
C336 vddd:291 0 0.0578066f
C337 vddd:287 0 0.0323528f
C338 vddd:278 0 0.0013383f
C339 vddd:274 0 0.0023229f
C340 vddd:265 0 7.04242e-19
C341 vddd:261 0 0.00391829f
C342 vddd:252 0 0.00149712f
C343 vddd:248 0 0.00379597f
R344_2 vddd:1273 vddd:1276 0.59375
R345_2 vddd:1256 vddd:1284 4.5125
R346_2 vddd:1255 vddd:1284 4.5125
R347_2 vddd:1254 vddd:1280 4.5125
R348_2 vddd:1253 vddd:1280 4.5125
R349_2 vddd:1252 vddd:1273 1.6625
R350_2 vddd:1251 vddd:1268 2.25625
R351_2 vddd:1250 vddd:1268 2.25625
R352_2 vddd:1249 vddd:1263 2.25625
R353_2 vddd:1248 vddd:1263 2.25625
R354_2 vddd:1247 vddd:1258 2.25625
R355_2 vddd:1246 vddd:1258 2.25625
R356_2 vddd:1204 vddd:1206 48.62
R357_2 vddd:1195 vddd:1197 70.125
R358_2 vddd:1193 vddd:1195 70.125
R359_2 vddd:1184 vddd:1186 70.125
R360_2 vddd:1175 vddd:1177 70.125
R361_2 vddd:1173 vddd:1175 70.125
R362_2 vddd:1164 vddd:1166 70.125
R363_2 vddd:1151 vddd:1153 70.125
R364_2 vddd:1142 vddd:1144 70.125
R365_2 vddd:1133 vddd:1135 70.125
R366_2 vddd:1131 vddd:1133 70.125
R367_2 vddd:1122 vddd:1124 70.125
R368_2 vddd:1113 vddd:1115 70.125
R369_2 vddd:1111 vddd:1113 70.125
R370_2 vddd:1088 vddd:1090 70.125
R371_2 vddd:1086 vddd:1088 70.125
R372_2 vddd:1084 vddd:1086 70.125
R373_2 vddd:1075 vddd:1077 70.125
R374_2 vddd:1073 vddd:1075 70.125
R375_2 vddd:1064 vddd:1066 70.125
R376_2 vddd:1062 vddd:1064 70.125
R377_2 vddd:1060 vddd:1062 70.125
R378_2 vddd:1051 vddd:1053 70.125
R379_2 vddd:1049 vddd:1051 70.125
R380_2 vddd:1040 vddd:1042 70.125
R381_2 vddd:1038 vddd:1040 70.125
R382_2 vddd:1036 vddd:1038 70.125
R383_2 vddd:1027 vddd:1029 70.125
R384_2 vddd:1025 vddd:1027 70.125
R385_2 vddd:1023 vddd:1025 70.125
R386_2 vddd:1010 vddd:1012 70.125
R387_2 vddd:1001 vddd:1003 70.125
R388_2 vddd:999 vddd:1001 70.125
R389_2 vddd:990 vddd:992 70.125
R390_2 vddd:988 vddd:990 70.125
R391_2 vddd:986 vddd:988 70.125
R392_2 vddd:977 vddd:979 70.125
R393_2 vddd:975 vddd:977 70.125
R394_2 vddd:966 vddd:968 70.125
R395_2 vddd:964 vddd:966 70.125
R396_2 vddd:962 vddd:964 70.125
R397_2 vddd:953 vddd:955 70.125
R398_2 vddd:951 vddd:953 70.125
R399_2 vddd:942 vddd:944 70.125
R400_2 vddd:940 vddd:942 70.125
R401_2 vddd:938 vddd:940 70.125
R402_2 vddd:915 vddd:917 72.93
R403_2 vddd:913 vddd:915 72.93
R404_2 vddd:911 vddd:913 72.93
R405_2 vddd:902 vddd:904 72.93
R406_2 vddd:900 vddd:902 71.995
R407_2 vddd:891 vddd:893 70.125
R408_2 vddd:889 vddd:891 70.125
R409_2 vddd:887 vddd:889 70.125
R410_2 vddd:878 vddd:880 70.125
R411_2 vddd:876 vddd:878 70.125
R412_2 vddd:867 vddd:869 70.125
R413_2 vddd:865 vddd:867 70.125
R414_2 vddd:863 vddd:865 70.125
R415_2 vddd:854 vddd:856 70.125
R416_2 vddd:852 vddd:854 70.125
R417_2 vddd:843 vddd:845 70.125
R418_2 vddd:837 vddd:839 70.125
R419_2 vddd:828 vddd:830 70.125
R420_2 vddd:826 vddd:828 70.125
R421_2 vddd:817 vddd:819 70.125
R422_2 vddd:815 vddd:817 70.125
R423_2 vddd:813 vddd:815 70.125
R424_2 vddd:804 vddd:806 70.125
R425_2 vddd:802 vddd:804 70.125
R426_2 vddd:793 vddd:795 70.125
R427_2 vddd:791 vddd:793 70.125
R428_2 vddd:789 vddd:791 70.125
R429_2 vddd:780 vddd:782 70.125
R430_2 vddd:778 vddd:780 70.125
R431_2 vddd:769 vddd:771 70.125
R432_2 vddd:767 vddd:769 70.125
R433_2 vddd:765 vddd:767 70.125
R434_2 vddd:749 vddd:751 46.75
R435_2 vddd:740 vddd:742 70.125
R436_2 vddd:738 vddd:740 70.125
R437_2 vddd:729 vddd:731 70.125
R438_2 vddd:720 vddd:722 70.125
R439_2 vddd:718 vddd:720 70.125
R440_2 vddd:709 vddd:711 70.125
R441_2 vddd:700 vddd:1104 5.22411
R442_2 vddd:700 vddd:930 5.22411
R443_2 vddd:700 vddd:1103 5.22411
R444_2 vddd:700 vddd:757 5.22411
R445_2 vddd:700 vddd:931 5.22411
R446_2 vddd:700 vddd:758 5.22411
R447_2 vddd:700 vddd:1104 9.3126
R448_2 vddd:700 vddd:1206 5.5726
R449_2 vddd:700 vddd:1204 42.4116
R450_2 vddd:700 vddd:1197 28.6484
R451_2 vddd:700 vddd:1193 9.8549
R452 vddd:700 vddd:1186 60.2701
R453 vddd:700 vddd:1184 48.3582
R454 vddd:700 vddd:1177 21.7668
R455 vddd:700 vddd:1173 16.7365
R456 vddd:700 vddd:1166 53.3885
R457 vddd:700 vddd:1164 55.2398
R458 vddd:700 vddd:1157 14.8852
R459 vddd:700 vddd:1157 21.505
R460 vddd:700 vddd:1153 48.62
R461 vddd:700 vddd:1151 23.6181
R462 vddd:700 vddd:1144 46.5069
R463 vddd:700 vddd:1142 62.1214
R464 vddd:700 vddd:1135 8.0036
R465 vddd:700 vddd:1131 30.4997
R466 vddd:700 vddd:1124 39.6253
R467 vddd:700 vddd:1122 69.003
R468 vddd:700 vddd:1115 1.122
R469 vddd:700 vddd:1111 37.3626
R470 vddd:700 vddd:1103 0.0374
R471 vddd:700 vddd:930 0.0374
R472 vddd:700 vddd:1097 37.3626
R473 vddd:700 vddd:1097 28.3492
R474 vddd:700 vddd:1090 18.4008
R475 vddd:700 vddd:1084 19.7659
R476 vddd:700 vddd:1077 50.3591
R477 vddd:700 vddd:1073 57.9326
R478 vddd:700 vddd:1066 12.1924
R479 vddd:700 vddd:1060 25.9743
R480 vddd:700 vddd:1053 44.1507
R481 vddd:700 vddd:1049 64.141
R482 vddd:700 vddd:1042 5.984
R483 vddd:700 vddd:1036 32.1827
R484 vddd:700 vddd:1029 37.9423
R485 vddd:700 vddd:1023 0.2244
R486 vddd:700 vddd:1016 69.9006
R487 vddd:700 vddd:1016 21.505
R488 vddd:700 vddd:1012 68.255
R489 vddd:700 vddd:1010 18.7561
R490 vddd:700 vddd:1003 51.3689
R491 vddd:700 vddd:999 56.9228
R492 vddd:700 vddd:992 13.2022
R493 vddd:700 vddd:986 24.9645
R494 vddd:700 vddd:979 45.1605
R495 vddd:700 vddd:975 63.1312
R496 vddd:700 vddd:968 6.9938
R497 vddd:700 vddd:962 31.1729
R498 vddd:700 vddd:955 38.9521
R499 vddd:700 vddd:951 69.3396
R500 vddd:700 vddd:944 0.7854
R501 vddd:700 vddd:938 37.3626
R502 vddd:700 vddd:931 0.0374
R503 vddd:700 vddd:757 0.0374
R504 vddd:700 vddd:924 39.2326
R505 vddd:700 vddd:924 26.4792
R506 vddd:700 vddd:917 22.1408
R507 vddd:700 vddd:911 7.6109
R508 vddd:700 vddd:904 65.3191
R509 vddd:700 vddd:900 38.2976
R510 vddd:700 vddd:893 31.8274
R511 vddd:700 vddd:887 6.3393
R512 vddd:700 vddd:880 63.7857
R513 vddd:700 vddd:876 44.506
R514 vddd:700 vddd:869 25.619
R515 vddd:700 vddd:863 12.5477
R516 vddd:700 vddd:856 57.5773
R517 vddd:700 vddd:852 50.7144
R518 vddd:700 vddd:845 19.4106
R519 vddd:700 vddd:843 1.87
R520 vddd:700 vddd:839 68.255
R521 vddd:700 vddd:837 18.7561
R522 vddd:700 vddd:830 51.3689
R523 vddd:700 vddd:826 56.9228
R524 vddd:700 vddd:819 13.2022
R525 vddd:700 vddd:813 24.9645
R526 vddd:700 vddd:806 45.1605
R527 vddd:700 vddd:802 63.1312
R528 vddd:700 vddd:795 6.9938
R529 vddd:700 vddd:789 31.1729
R530 vddd:700 vddd:782 38.9521
R531 vddd:700 vddd:778 69.3396
R532 vddd:700 vddd:771 0.7854
R533 vddd:700 vddd:765 37.3626
R534 vddd:700 vddd:758 0.0374
R535 vddd:700 vddd:751 13.9876
R536 vddd:700 vddd:749 40.8408
R537 vddd:700 vddd:742 29.2842
R538 vddd:700 vddd:738 9.7053
R539 vddd:700 vddd:731 60.4197
R540 vddd:700 vddd:729 48.6948
R541 vddd:700 vddd:722 21.4302
R542 vddd:700 vddd:718 17.5593
R543 vddd:700 vddd:711 52.5657
R544 vddd:700 vddd:709 56.5488
R545 vddd:700 vddd:702 13.5762
R546 vddd:700 vddd:702 25.245
R547 vddd:698 vddd:700 44.88
R548 vddd:696 vddd:698 70.125
R549 vddd:696 vddd:700 25.4133
R550 vddd:689 vddd:700 44.7117
R551 vddd:687 vddd:689 70.125
R552 vddd:687 vddd:700 64.4028
R553 vddd:680 vddd:700 5.7222
R554 vddd:678 vddd:680 70.125
R555 vddd:676 vddd:678 70.125
R556 vddd:676 vddd:700 33.2673
R557 vddd:669 vddd:700 36.8577
R558 vddd:667 vddd:669 70.125
R559 vddd:665 vddd:667 70.125
R560 vddd:665 vddd:700 2.1318
R561 vddd:658 vddd:700 67.9932
R562 vddd:656 vddd:658 71.995
R563 vddd:656 vddd:700 39.2326
R564 vddd:649 vddd:700 5.22411
R565 vddd:649 vddd:700 0.0374
R566 vddd:648 vddd:700 5.22411
R567 vddd:648 vddd:700 0.0374
R568 vddd:644 vddd:646 34.9067
R569 vddd:630 vddd:631 1.62857
R570 vddd:628 vddd:630 0.55651
R571 vddd:626 vddd:631 0.360094
R572 vddd:624 vddd:625 0.171268
R573 vddd:623 vddd:632 0.0931119
R574 vddd:623 vddd:624 0.201019
R575 vddd:622 vddd:626 0.27716
R576 vddd:622 vddd:625 0.201019
R577 vddd:620 vddd:621 1.62857
R578 vddd:619 vddd:620 0.0982076
R579 vddd:616 vddd:619 0.456172
R580 vddd:614 vddd:632 0.139957
R581 vddd:614 vddd:621 0.360094
R582 vddd:610 vddd:632 0.0931119
R583 vddd:610 vddd:612 5.2533
R584 vddd:607 vddd:700 80
R585 vddd:607 vddd:1206 80
R586 vddd:607 vddd:1097 40
R587 vddd:603 vddd:1111 26.6667
R588 vddd:603 vddd:700 80
R589 vddd:603 vddd:924 40
R590 vddd:594 vddd:765 26.6667
R591 vddd:594 vddd:656 26.6667
R592 vddd:594 vddd:700 80
R593 vddd:588 vddd:1204 26.6667
R594 vddd:586 vddd:1197 26.6667
R595 vddd:586 vddd:588 0.210671
R596 vddd:584 vddd:1195 26.6667
R597 vddd:584 vddd:586 0.207899
R598 vddd:582 vddd:1193 26.6667
R599 vddd:582 vddd:584 0.207899
R600 vddd:580 vddd:1186 26.6667
R601 vddd:580 vddd:582 0.207899
R602 vddd:578 vddd:1184 26.6667
R603 vddd:578 vddd:580 0.207899
R604 vddd:576 vddd:1177 26.6667
R605 vddd:576 vddd:578 0.207899
R606 vddd:574 vddd:1175 26.6667
R607 vddd:574 vddd:576 0.207899
R608 vddd:572 vddd:1173 26.6667
R609 vddd:572 vddd:574 0.207899
R610 vddd:570 vddd:1166 26.6667
R611 vddd:570 vddd:572 0.207899
R612 vddd:568 vddd:1164 26.6667
R613 vddd:568 vddd:570 0.207899
R614 vddd:566 vddd:1157 26.6667
R615 vddd:566 vddd:568 0.207899
R616 vddd:564 vddd:1153 26.6667
R617 vddd:564 vddd:566 0.207899
R618 vddd:562 vddd:1151 26.6667
R619 vddd:562 vddd:564 0.207899
R620 vddd:560 vddd:1144 26.6667
R621 vddd:560 vddd:562 0.207899
R622 vddd:558 vddd:1142 26.6667
R623 vddd:558 vddd:560 0.207899
R624 vddd:556 vddd:1135 26.6667
R625 vddd:556 vddd:558 0.207899
R626 vddd:554 vddd:1133 26.6667
R627 vddd:554 vddd:556 0.207899
R628 vddd:552 vddd:1131 26.6667
R629 vddd:552 vddd:554 0.207899
R630 vddd:550 vddd:1124 26.6667
R631 vddd:550 vddd:552 0.207899
R632 vddd:548 vddd:1122 26.6667
R633 vddd:548 vddd:550 0.207899
R634 vddd:546 vddd:1115 26.6667
R635 vddd:546 vddd:548 0.207899
R636 vddd:544 vddd:1113 26.6667
R637 vddd:544 vddd:546 0.207899
R638 vddd:542 vddd:607 0.116976
R639 vddd:542 vddd:588 0.0776155
R640 vddd:541 vddd:603 0.116976
R641 vddd:541 vddd:544 0.180179
R642 vddd:539 vddd:628 4.5
R643 vddd:536 vddd:1284 45
R644 vddd:536 vddd:539 0.426828
R645 vddd:533 vddd:616 4.5
R646 vddd:530 vddd:1280 45
R647 vddd:530 vddd:533 0.426828
R648 vddd:528 vddd:1090 26.6667
R649 vddd:526 vddd:1088 26.6667
R650 vddd:526 vddd:528 0.207899
R651 vddd:524 vddd:1086 26.6667
R652 vddd:524 vddd:526 0.207899
R653 vddd:522 vddd:1084 26.6667
R654 vddd:522 vddd:524 0.207899
R655 vddd:520 vddd:1077 26.6667
R656 vddd:520 vddd:522 0.207899
R657 vddd:518 vddd:1075 26.6667
R658 vddd:518 vddd:520 0.207899
R659 vddd:516 vddd:1073 26.6667
R660 vddd:516 vddd:518 0.207899
R661 vddd:514 vddd:1066 26.6667
R662 vddd:514 vddd:516 0.207899
R663 vddd:512 vddd:1064 26.6667
R664 vddd:512 vddd:514 0.207899
R665 vddd:510 vddd:1062 26.6667
R666 vddd:510 vddd:512 0.207899
R667 vddd:508 vddd:1060 26.6667
R668 vddd:508 vddd:510 0.207899
R669 vddd:506 vddd:1053 26.6667
R670 vddd:506 vddd:508 0.207899
R671 vddd:504 vddd:1051 26.6667
R672 vddd:504 vddd:506 0.207899
R673 vddd:502 vddd:1049 26.6667
R674 vddd:502 vddd:504 0.207899
R675 vddd:500 vddd:1042 26.6667
R676 vddd:500 vddd:502 0.207899
R677 vddd:498 vddd:1040 26.6667
R678 vddd:498 vddd:500 0.207899
R679 vddd:496 vddd:1038 26.6667
R680 vddd:496 vddd:498 0.207899
R681 vddd:494 vddd:1036 26.6667
R682 vddd:494 vddd:496 0.207899
R683 vddd:492 vddd:1029 26.6667
R684 vddd:492 vddd:494 0.207899
R685 vddd:490 vddd:1027 26.6667
R686 vddd:490 vddd:492 0.207899
R687 vddd:488 vddd:1025 26.6667
R688 vddd:488 vddd:490 0.207899
R689 vddd:486 vddd:1023 26.6667
R690 vddd:486 vddd:488 0.207899
R691 vddd:484 vddd:1016 26.6667
R692 vddd:484 vddd:486 0.207899
R693 vddd:482 vddd:1012 26.6667
R694 vddd:482 vddd:484 0.26611
R695 vddd:480 vddd:1010 26.6667
R696 vddd:480 vddd:482 0.207899
R697 vddd:478 vddd:1003 26.6667
R698 vddd:478 vddd:480 0.207899
R699 vddd:476 vddd:1001 26.6667
R700 vddd:476 vddd:478 0.207899
R701 vddd:474 vddd:999 26.6667
R702 vddd:474 vddd:476 0.207899
R703 vddd:472 vddd:992 26.6667
R704 vddd:472 vddd:474 0.207899
R705 vddd:470 vddd:990 26.6667
R706 vddd:470 vddd:472 0.207899
R707 vddd:468 vddd:988 26.6667
R708 vddd:468 vddd:470 0.207899
R709 vddd:466 vddd:986 26.6667
R710 vddd:466 vddd:468 0.207899
R711 vddd:464 vddd:979 26.6667
R712 vddd:464 vddd:466 0.207899
R713 vddd:462 vddd:977 26.6667
R714 vddd:462 vddd:464 0.207899
R715 vddd:460 vddd:975 26.6667
R716 vddd:460 vddd:462 0.207899
R717 vddd:458 vddd:968 26.6667
R718 vddd:458 vddd:460 0.207899
R719 vddd:456 vddd:966 26.6667
R720 vddd:456 vddd:458 0.207899
R721 vddd:454 vddd:964 26.6667
R722 vddd:454 vddd:456 0.207899
R723 vddd:452 vddd:962 26.6667
R724 vddd:452 vddd:454 0.207899
R725 vddd:450 vddd:955 26.6667
R726 vddd:450 vddd:452 0.207899
R727 vddd:448 vddd:953 26.6667
R728 vddd:448 vddd:450 0.207899
R729 vddd:446 vddd:951 26.6667
R730 vddd:446 vddd:448 0.207899
R731 vddd:444 vddd:944 26.6667
R732 vddd:444 vddd:446 0.207899
R733 vddd:442 vddd:942 26.6667
R734 vddd:442 vddd:444 0.207899
R735 vddd:440 vddd:940 26.6667
R736 vddd:440 vddd:442 0.207899
R737 vddd:438 vddd:440 0.194039
R738 vddd:437 vddd:607 0.116976
R739 vddd:437 vddd:528 0.110879
R740 vddd:436 vddd:917 26.6667
R741 vddd:434 vddd:915 26.6667
R742 vddd:434 vddd:436 0.216215
R743 vddd:432 vddd:913 26.6667
R744 vddd:432 vddd:434 0.216215
R745 vddd:430 vddd:911 26.6667
R746 vddd:430 vddd:432 0.216215
R747 vddd:428 vddd:904 26.6667
R748 vddd:428 vddd:430 0.216215
R749 vddd:426 vddd:902 26.6667
R750 vddd:426 vddd:428 0.216215
R751 vddd:424 vddd:900 26.6667
R752 vddd:424 vddd:426 0.213443
R753 vddd:422 vddd:893 26.6667
R754 vddd:422 vddd:424 0.207899
R755 vddd:420 vddd:891 26.6667
R756 vddd:420 vddd:422 0.207899
R757 vddd:418 vddd:889 26.6667
R758 vddd:418 vddd:420 0.207899
R759 vddd:416 vddd:887 26.6667
R760 vddd:416 vddd:418 0.207899
R761 vddd:414 vddd:880 26.6667
R762 vddd:414 vddd:416 0.207899
R763 vddd:412 vddd:878 26.6667
R764 vddd:412 vddd:414 0.207899
R765 vddd:410 vddd:876 26.6667
R766 vddd:410 vddd:412 0.207899
R767 vddd:408 vddd:869 26.6667
R768 vddd:408 vddd:410 0.207899
R769 vddd:406 vddd:867 26.6667
R770 vddd:406 vddd:408 0.207899
R771 vddd:404 vddd:865 26.6667
R772 vddd:404 vddd:406 0.207899
R773 vddd:402 vddd:863 26.6667
R774 vddd:402 vddd:404 0.207899
R775 vddd:400 vddd:856 26.6667
R776 vddd:400 vddd:402 0.207899
R777 vddd:398 vddd:854 26.6667
R778 vddd:398 vddd:400 0.207899
R779 vddd:396 vddd:852 26.6667
R780 vddd:396 vddd:398 0.207899
R781 vddd:394 vddd:845 26.6667
R782 vddd:394 vddd:396 0.207899
R783 vddd:392 vddd:843 26.6667
R784 vddd:392 vddd:394 0.207899
R785 vddd:390 vddd:839 26.6667
R786 vddd:390 vddd:392 0.207899
R787 vddd:388 vddd:837 26.6667
R788 vddd:388 vddd:390 0.207899
R789 vddd:386 vddd:830 26.6667
R790 vddd:386 vddd:388 0.207899
R791 vddd:384 vddd:828 26.6667
R792 vddd:384 vddd:386 0.207899
R793 vddd:382 vddd:826 26.6667
R794 vddd:382 vddd:384 0.207899
R795 vddd:380 vddd:819 26.6667
R796 vddd:380 vddd:382 0.207899
R797 vddd:378 vddd:817 26.6667
R798 vddd:378 vddd:380 0.207899
R799 vddd:376 vddd:815 26.6667
R800 vddd:376 vddd:378 0.207899
R801 vddd:374 vddd:813 26.6667
R802 vddd:374 vddd:376 0.207899
R803 vddd:372 vddd:806 26.6667
R804 vddd:372 vddd:374 0.207899
R805 vddd:370 vddd:804 26.6667
R806 vddd:370 vddd:372 0.207899
R807 vddd:368 vddd:802 26.6667
R808 vddd:368 vddd:370 0.207899
R809 vddd:366 vddd:795 26.6667
R810 vddd:366 vddd:368 0.207899
R811 vddd:364 vddd:793 26.6667
R812 vddd:364 vddd:366 0.207899
R813 vddd:362 vddd:791 26.6667
R814 vddd:362 vddd:364 0.207899
R815 vddd:360 vddd:789 26.6667
R816 vddd:360 vddd:362 0.207899
R817 vddd:358 vddd:782 26.6667
R818 vddd:358 vddd:360 0.207899
R819 vddd:356 vddd:780 26.6667
R820 vddd:356 vddd:358 0.207899
R821 vddd:354 vddd:778 26.6667
R822 vddd:354 vddd:356 0.207899
R823 vddd:352 vddd:771 26.6667
R824 vddd:352 vddd:354 0.207899
R825 vddd:350 vddd:769 26.6667
R826 vddd:350 vddd:352 0.207899
R827 vddd:348 vddd:767 26.6667
R828 vddd:348 vddd:350 0.207899
R829 vddd:346 vddd:594 0.116976
R830 vddd:346 vddd:348 0.194039
R831 vddd:345 vddd:603 0.116976
R832 vddd:345 vddd:436 0.121967
R833 vddd:344 vddd:749 26.6667
R834 vddd:342 vddd:742 26.6667
R835 vddd:342 vddd:344 0.207899
R836 vddd:340 vddd:740 26.6667
R837 vddd:340 vddd:342 0.207899
R838 vddd:338 vddd:738 26.6667
R839 vddd:338 vddd:340 0.207899
R840 vddd:336 vddd:731 26.6667
R841 vddd:336 vddd:338 0.207899
R842 vddd:334 vddd:729 26.6667
R843 vddd:334 vddd:336 0.207899
R844 vddd:332 vddd:612 1.5
R845 vddd:332 vddd:334 0.191267
R846 vddd:330 vddd:722 26.6667
R847 vddd:330 vddd:332 0.0166319
R848 vddd:328 vddd:720 26.6667
R849 vddd:328 vddd:330 0.207899
R850 vddd:326 vddd:718 26.6667
R851 vddd:326 vddd:328 0.207899
R852 vddd:324 vddd:344 0.0692996
R853 vddd:323 vddd:597 0.050263
R854 vddd:323 vddd:326 0.0887034
R855 vddd:322 vddd:711 26.6667
R856 vddd:320 vddd:709 26.6667
R857 vddd:320 vddd:322 0.207899
R858 vddd:318 vddd:702 26.6667
R859 vddd:318 vddd:320 0.207899
R860 vddd:316 vddd:698 26.6667
R861 vddd:316 vddd:318 0.207899
R862 vddd:314 vddd:696 26.6667
R863 vddd:314 vddd:316 0.207899
R864 vddd:312 vddd:689 26.6667
R865 vddd:312 vddd:314 0.207899
R866 vddd:310 vddd:687 26.6667
R867 vddd:310 vddd:312 0.207899
R868 vddd:308 vddd:680 26.6667
R869 vddd:308 vddd:310 0.207899
R870 vddd:306 vddd:678 26.6667
R871 vddd:306 vddd:308 0.207899
R872 vddd:304 vddd:676 26.6667
R873 vddd:304 vddd:306 0.207899
R874 vddd:302 vddd:669 26.6667
R875 vddd:302 vddd:304 0.207899
R876 vddd:300 vddd:667 26.6667
R877 vddd:300 vddd:302 0.207899
R878 vddd:298 vddd:665 26.6667
R879 vddd:298 vddd:300 0.207899
R880 vddd:296 vddd:658 26.6667
R881 vddd:296 vddd:298 0.207899
R882 vddd:294 vddd:597 0.050263
R883 vddd:294 vddd:322 0.0360358
R884 vddd:293 vddd:594 0.116976
R885 vddd:293 vddd:296 0.191267
R886 vddd:292 vddd:592 0.0657228
R887 vddd:291 vddd:597 0.224575
R888 vddd:291 vddd:292 2.88717
R889 vddd:289 vddd:1276 90
R890 vddd:286 vddd:1276 30
R891 vddd:286 vddd:289 0.859931
R892 vddd:286 vddd:287 0.630616
R893 vddd:284 vddd:592 0.19296
R894 vddd:284 vddd:287 0.66435
R895 vddd:282 vddd:283 0.116583
R896 vddd:281 vddd:646 80
R897 vddd:281 vddd:283 0.156063
R898 vddd:279 vddd:591 0.0657228
R899 vddd:279 vddd:282 0.178358
R900 vddd:278 vddd:592 0.0657228
R901 vddd:278 vddd:281 0.0222948
R902 vddd:276 vddd:1268 90
R903 vddd:273 vddd:1268 30
R904 vddd:273 vddd:276 1.6006
R905 vddd:273 vddd:274 1.17378
R906 vddd:271 vddd:591 0.19296
R907 vddd:271 vddd:274 0.670604
R908 vddd:269 vddd:270 0.116583
R909 vddd:268 vddd:644 26.6667
R910 vddd:268 vddd:270 0.111474
R911 vddd:266 vddd:590 0.0657228
R912 vddd:266 vddd:269 0.178358
R913 vddd:265 vddd:591 0.0657228
R914 vddd:265 vddd:268 0.0668843
R915 vddd:263 vddd:1263 90
R916 vddd:260 vddd:1263 30
R917 vddd:260 vddd:263 1.6006
R918 vddd:260 vddd:261 1.17378
R919 vddd:258 vddd:590 0.19296
R920 vddd:258 vddd:261 0.670604
R921 vddd:256 vddd:257 0.116583
R922 vddd:255 vddd:638 26.6667
R923 vddd:255 vddd:256 0.133769
R924 vddd:253 vddd:589 0.0657228
R925 vddd:253 vddd:255 0.0445895
R926 vddd:252 vddd:590 0.0657228
R927 vddd:252 vddd:257 0.178358
R928 vddd:250 vddd:1258 90
R929 vddd:247 vddd:1258 30
R930 vddd:247 vddd:250 1.6006
R931 vddd:247 vddd:248 1.17378
R932 vddd:245 vddd:589 0.19296
R933 vddd:245 vddd:248 0.66435
R934 vddd:240 vddd:938 26.6667
R935 vddd:240 vddd:700 80
R936 vddd:240 vddd:751 80
R937 vddd:240 vddd:324 0.116976
R938 vddd:240 vddd:438 0.116976
R939 vddd:3 vddd:644 17.4533
R940 vddd:3 vddd:638 34.9067
** vddd 7.26137e-15 *
C51 net8:6 enableb:50 2.4576e-19
C52 net8:12 enableb:50 0.00136006f
C53 net8:15 enableb:50 0.00205847f
C54 net8:3 vssd:124 0.0131302f
C55 net8:3 vssd:223 2.8998e-19
C56 net8:6 vssd:313 3.22563e-19
C57 net8:7 vssd:140 0.0435427f
C58 net8:7 vssd:313 0.00958914f
C59 net8:12 vssd:124 3.58834e-19
C60 net8:15 vssd:313 4.65368e-19
C61 net8:24 vssd:313 3.22563e-19
C62 MM7:s vssd:124 2.8998e-19
C63 MM7:s vssd:223 0.00433812f
C82 net8:51 0 0.00362378f
C83 net8:40 0 7.02662e-20
C84 net8:38 0 7.02662e-20
C85 net8:35 0 0.00357031f
C86 net8:34 0 4.13735e-19
C87 net8:33 0 2.36437e-19
C88 net8:30 0 0.00219624f
C89 net8:24 0 0.00398527f
C90 net8:21 0 0.00160353f
C91 net8:15 0 0.00661241f
C92 net8:12 0 0.00599082f
C93 net8:7 0 7.42468e-19
C94 net8:6 0 0.00236742f
C95 net8:3 0 0.00518712f
R96 net8:48 net8:51 1.0625
R97 net8:42 net8:45 1.0625
R98 net8:40 net8:58 4.0375
R99 net8:39 net8:58 4.0375
R100 net8:38 net8:54 4.0375
R101 net8:37 net8:54 4.0375
R102 net8:36 net8:48 2.975
R103 net8:35 net8:45 2.975
R104 net8:30 net8:58 40
R105 net8:30 net8:32 1.35162
R106 net8:28 net8:32 0.379629
R107 net8:26 net8:27 0.297078
R108 net8:25 net8:34 0.181184
R109 net8:25 net8:26 0.307495
R110 net8:24 net8:28 0.239069
R111 net8:24 net8:27 0.307495
R112 net8:21 net8:54 40
R113 net8:21 net8:23 1.35162
R114 net8:19 net8:34 0.0470866
R115 net8:19 net8:23 0.379629
R116 net8:17 net8:18 0.297078
R117 net8:16 net8:33 0.181184
R118 net8:16 net8:17 0.807173
R119 net8:15 net8:34 0.181184
R120 net8:15 net8:18 0.307495
R121 net8:12 net8:51 40
R122 net8:12 net8:14 0.770993
R123 net8:10 net8:33 0.0470866
R124 net8:10 net8:14 0.379629
R125 net8:8 net8:9 0.297078
R126 net8:7 net8:8 0.307495
R127 net8:6 net8:33 0.181184
R128 net8:6 net8:9 0.307495
R129 net8:3 net8:42 40
R130 net8:3 net8:5 0.770993
R131 net8:1 net8:7 0.239069
R132 net8:1 net8:5 0.383202
** net8 4.43009e-16 *
C64 net13:1 enableb:21 0.00141815f
C65 net13:5 MM14:g 0.0155342f
C66 net13:5 enableb:5 7.55916e-19
C67 net13:81 enableb:30 0.00248414f
C68 net13:154 enableb:84 0.0250983f
C69 net13:163 MM14:g 2.08867e-19
C70 net13:180 enableb:5 0.00240125f
C71 net13:180 enableb:21 0.00405487f
C72 net13:180 enableb:26 8.39206e-19
C73 net13:180 enableb:36 5.09554e-19
C74 net13:180 enableb:63 9.52434e-19
C75 net13:180 enableb:68 0.00338417f
C76 net13:180 enableb:77 0.132927f
C77 net13:1 vssd:70 0.00164334f
C78 net13:1 vssd:113 0.00154208f
C79 net13:1 vssd:144 0.00466423f
C80 net13:1 vssd:326 3.73838e-19
C81 net13:5 vssd:113 4.92504e-19
C82_2 net13:5 MM13:s 0.015476f
C83_2 net13:5 vssd:326 5.95289e-19
C84_2 net13:71 vssd:117 2.19962e-19
C85_2 net13:79 vssd:82 0.0129807f
C86_2 net13:79 vssd:117 0.0249651f
C87_2 net13:79 vssd:313 0.016938f
C88_2 net13:93 vssd:313 6.75526e-19
C89_2 net13:102 vssd:144 0.0046528f
C90_2 net13:102 vssd:146 0.00153872f
C91_2 net13:102 vssd:153 0.0046528f
C92_2 net13:102 vssd:326 3.73838e-19
C93_2 net13:108 vssd:153 0.0046528f
C94_2 net13:108 vssd:155 0.00154208f
C95_2 net13:108 vssd:164 0.0046528f
C96 net13:108 vssd:326 3.73838e-19
C97 net13:119 vssd:140 0.0249651f
C98 net13:119 vssd:313 6.75526e-19
C99 net13:143 vssd:191 0.0249651f
C100 net13:149 vssd:70 0.00107869f
C101 net13:149 vssd:113 0.0113208f
C102 net13:154 vssd:82 0.00660001f
C103 net13:154 vssd:117 5.55222e-19
C104 net13:163 vssd:70 0.00161485f
C105 net13:163 vssd:144 0.00365137f
C106 net13:165 vssd:144 0.00827868f
C107 net13:165 vssd:146 0.00369057f
C108 net13:169 vssd:144 0.00275921f
C109 net13:169 vssd:153 0.00275921f
C110 net13:171 vssd:153 0.00726624f
C111 net13:171 vssd:155 0.00246114f
C112 net13:171 vssd:164 0.00187566f
C113 net13:175 vssd:153 0.00275921f
C114 net13:175 vssd:164 0.00195707f
C115 net13:180 vssd:70 0.00696507f
C116 net13:180 vssd:113 0.00103165f
C117 net13:180 vssd:117 0.00939054f
C118 net13:180 vssd:124 0.00730774f
C119 net13:180 vssd:144 5.47985e-19
C120 MM13@4:d vssd:146 7.8465e-19
C121 MM13@4:d MM13:s 0.015476f
C122 MM13@4:d MM13@3:s 0.015476f
C123_2 MM13@4:d vssd:326 7.79607e-19
C124_2 MM13@2:d vssd:155 9.45002e-19
C125_2 MM13@2:d MM13@3:s 0.015476f
C126_2 MM13@2:d MM5:s 0.015476f
C127_2 MM13@2:d vssd:326 7.79607e-19
C128_2 net13:8 vddd:296 3.62134e-19
C129_2 net13:24 vddd:296 3.6756e-19
C130_2 net13:97 vddd:589 0.00559663f
C131_2 net13:123 vddd:590 0.00559663f
C132_2 net13:133 vddd:296 0.0135655f
C133_2 net13:135 vddd:592 0.00559663f
C134_2 net13:146 vddd:589 0.00559663f
C135_2 net13:148 vddd:591 0.00559663f
C136_2 net13:93 net8:7 0.00164104f
C137_2 net13:119 net8:34 0.00164104f
C138_2 net13:145 net8:33 0.00164104f
C224 net13:180 0 0.0468376f
C225 net13:178 0 5.82332e-19
C226 net13:177 0 6.0193e-19
C227 net13:175 0 4.12098e-19
C228 net13:171 0 0.00541775f
C229 net13:169 0 3.45574e-19
C230 net13:165 0 0.00442019f
C231 net13:163 0 0.00222237f
C232_2 net13:154 0 0.00215229f
C233_2 net13:149 0 0.00779965f
C234_2 net13:148 0 6.61088e-19
C235_2 net13:147 0 4.54878e-19
C236_2 net13:146 0 6.86959e-19
C237_2 net13:145 0 2.6598e-19
C238_2 net13:144 0 0.00138744f
C239_2 net13:143 0 3.00455e-19
C240_2 net13:139 0 0.0817874f
C241_2 net13:135 0 0.00657168f
C242_2 net13:133 0 0.00520222f
C243_2 net13:123 0 0.0124487f
C244_2 net13:119 0 0.00782308f
C245_2 net13:108 0 0.00107908f
C246_2 net13:102 0 8.97409e-19
C247_2 net13:97 0 0.0139121f
C248_2 net13:93 0 0.00797187f
C249_2 net13:81 0 0.00177531f
C250_2 net13:80 0 0.00679414f
C251_2 net13:79 0 0.00134666f
C252_2 net13:78 0 0.00375184f
C253_2 net13:71 0 0.0586612f
C254_2 net13:36 0 2.19246e-20
C255_2 net13:35 0 0.0211511f
C256_2 net13:33 0 0.0209955f
C257_2 net13:24 0 0.00540825f
C258_2 net13:23 0 0.00307912f
C259_2 net13:22 0 0.00531747f
C260_2 net13:20 0 7.99794e-20
C261_2 net13:19 0 0.0210665f
C262_2 net13:17 0 0.0210665f
C263_2 net13:8 0 0.00536626f
C264_2 net13:7 0 0.00183312f
C265_2 net13:6 0 0.00531747f
C266 net13:5 0 0.0134653f
C267 net13:1 0 0.00823581f
R268_2 net13:191 net13:209 4.0375
R269_2 net13:190 net13:209 4.0375
R270_2 net13:189 net13:205 4.0375
R271_2 net13:188 net13:205 4.0375
R272_2 net13:183 net13:186 2.11757
R273_2 net13:183 net13:184 5.07545
R274_2 net13:180 net13:184 2.00609
R275_2 net13:173 net13:175 0.70055
R276_2 net13:172 net13:178 0.176721
R277_2 net13:171 net13:173 0.233181
R278_2 net13:171 net13:172 0.698694
R279_2 net13:167 net13:178 0.0459268
R280_2 net13:167 net13:169 0.70055
R281_2 net13:166 net13:177 0.176721
R282_2 net13:165 net13:178 0.176721
R283_2 net13:165 net13:166 0.698694
R284_2 net13:161 net13:177 0.0459268
R285_2 net13:161 net13:163 0.703821
R286_2 net13:158 net13:186 1.5
R287_2 net13:154 net13:183 1.5
R288_2 net13:154 net13:158 2.09608
R289_2 net13:151 net13:180 8
R290_2 net13:149 net13:177 0.176721
R291_2 net13:149 net13:151 0.665423
R292_2 net13:141 net13:142 0.382416
R293_2 net13:140 net13:141 0.605447
R294_2 net13:139 net13:140 0.382416
R295_2 net13:138 net13:142 1.57491
R296_2 net13:137 net13:139 1.57491
R297_2 net13:136 net13:148 0.181184
R298_2 net13:135 net13:138 0.239069
R299_2 net13:135 net13:136 0.535382
R300_2 net13:134 net13:147 0.181184
R301_2 net13:133 net13:137 0.239069
R302_2 net13:133 net13:134 0.536946
R303_2 net13:130 net13:148 0.0470866
R304_2 net13:127 net13:147 0.0470866
R305_2 net13:125 net13:126 0.192924
R306_2 net13:124 net13:146 0.181184
R307_2 net13:124 net13:125 1.07076
R308_2 net13:123 net13:148 0.181184
R309_2 net13:123 net13:126 1.07076
R310_2 net13:121 net13:122 0.282995
R311_2 net13:120 net13:145 0.181184
R312_2 net13:120 net13:121 1.07389
R313_2 net13:119 net13:147 0.181184
R314_2 net13:119 net13:122 1.07389
R315_2 net13:116 net13:146 0.0470866
R316_2 net13:113 net13:145 0.0470866
R317_2 net13:111 net13:175 4.5
R318_2 net13:108 net13:209 40
R319_2 net13:108 net13:111 0.426828
R320_2 net13:105 net13:169 4.5
R321_2 net13:102 net13:205 40
R322_2 net13:102 net13:105 0.426828
R323_2 net13:99 net13:100 0.192924
R324_2 net13:98 net13:144 0.181184
R325_2 net13:98 net13:99 1.07076
R326_2 net13:97 net13:146 0.181184
R327_2 net13:97 net13:100 1.07076
R328_2 net13:95 net13:96 0.282995
R329_2 net13:94 net13:143 0.181184
R330_2 net13:94 net13:95 1.07389
R331_2 net13:93 net13:145 0.181184
R332_2 net13:93 net13:96 1.07389
R333_2 net13:91 net13:163 4.5
R334_2 net13:85 net13:144 0.0470866
R335_2 net13:82 net13:143 0.0470866
R336_2 net13:80 net13:144 0.181184
R337_2 net13:80 net13:81 0.535382
R338_2 net13:78 net13:143 0.181184
R339_2 net13:78 net13:79 0.536946
R340_2 net13:76 net13:77 0.382416
R341_2 net13:75 net13:76 0.605447
R342_2 net13:74 net13:75 0.382416
R343_2 net13:73 net13:158 1.5
R344_3 net13:73 net13:77 0.51857
R345_3 net13:71 net13:154 1.5
R346_3 net13:71 net13:74 0.51857
R347_3 net13:69 net13:81 0.239069
R348_3 net13:69 net13:73 1.05635
R349_3 net13:68 net13:79 0.239069
R350_3 net13:68 net13:71 1.05635
R351_3 net13:33 net13:37 0.730469
R352_3 net13:29 net13:35 0.724625
R353_3 net13:28 net13:37 4.52891
R354_3 net13:27 net13:36 5.25938
R355_3 net13:26 net13:36 5.25938
R356_3 net13:25 net13:35 4.52891
R357_3 net13:24 net13:130 0.960314
R358_3 net13:24 net13:33 26.6667
R359_3 net13:23 net13:116 0.956039
R360_3 net13:23 net13:36 26.6667
R361_3 net13:22 net13:85 0.960314
R362_3 net13:22 net13:29 26.6667
R363_3 net13:17 net13:21 0.730469
R364_3 net13:13 net13:19 0.724625
R365_3 net13:12 net13:21 4.52891
R366_3 net13:11 net13:20 5.25938
R367_3 net13:10 net13:20 5.25938
R368_3 net13:9 net13:19 4.52891
R369_3 net13:8 net13:127 0.960314
R370_3 net13:8 net13:17 26.6667
R371_3 net13:7 net13:113 0.956039
R372_3 net13:7 net13:20 26.6667
R373_3 net13:6 net13:82 0.960314
R374_3 net13:6 net13:13 26.6667
R375_3 net13:3 net13:5 1.0625
R376_3 net13:2 net13:5 2.975
R377_3 net13:1 net13:91 0.229315
R378_3 net13:1 net13:3 40
** net13 1.61205e-15 *
C139_2 net5:82 enableb:68 8.97439e-19
C140_2 net5:90 enableb:73 0.00121877f
C141_2 net5:90 enableb:84 7.68807e-19
C142_2 net5:93 enableb:84 0.00213712f
C143_2 net5:82 vssd:124 0.00231843f
C144 net5:84 vssd:140 0.047203f
C145 net5:85 vssd:140 0.00255582f
C146 net5:138 vssd:140 4.36739e-19
C147 net5:24 vddd:248 0.00428502f
C148 net5:24 vddd:252 0.00149046f
C149 net5:24 vddd:261 0.00428502f
C150 net5:24 vddd:646 2.61596e-19
C151 net5:32 vddd:261 0.00428502f
C152 net5:32 vddd:265 0.00177695f
C153 net5:32 vddd:274 0.00428502f
C154 net5:32 vddd:646 2.61596e-19
C155 net5:40 vddd:274 0.00428502f
C156 net5:40 vddd:278 0.00149046f
C157 net5:40 vddd:287 0.00428502f
C158 net5:40 vddd:646 2.61596e-19
C159 net5:47 vddd:326 0.00112793f
C160 net5:47 vddd:610 3.16701e-19
C161 net5:63 vddd:610 0.00119368f
C162 net5:63 vddd:616 5.19463e-19
C163 net5:90 vddd:248 0.00690948f
C164 net5:90 vddd:261 0.00457385f
C165 net5:92 vddd:261 0.00674509f
C166 net5:92 vddd:265 0.00307871f
C167 net5:93 vddd:248 0.00350184f
C168 net5:93 vddd:252 0.00117773f
C169 net5:96 vddd:261 0.00366461f
C170 net5:96 vddd:274 0.00366461f
C171 net5:98 vddd:274 0.00696968f
C172 net5:98 vddd:278 0.00143248f
C173 net5:102 vddd:274 0.00457385f
C174 net5:102 vddd:287 0.0124897f
C175 net5:104 vddd:287 0.00805069f
C176 net5:104 vddd:291 0.0525905f
C177 net5:106 vddd:296 0.0653472f
C178 net5:110 vddd:296 0.00448059f
C179 net5:110 vddd:616 0.00103117f
C180 net5:115 vddd:597 0.0013099f
C181 net5:115 vddd:610 0.0106642f
C182 net5:120 vddd:616 0.00404655f
C183 net5:127 vddd:628 9.59209e-19
C184 net5:138 vddd:296 0.0117667f
C185 net5:143 vddd:296 0.00591841f
C186 net5:148 vddd:287 5.12518e-19
C187 net5:148 vddd:291 0.0139636f
C188 net5:148 vddd:326 0.00868135f
C189 net5:153 vddd:616 9.59209e-19
C190 net5:155 vddd:291 0.00799285f
C191 net5:155 vddd:296 0.0355386f
C192 net5:155 vddd:326 2.99773e-19
C193 MM9@2:d vddd:252 0.00133009f
C194 MM9@2:d vddd:646 0.00180658f
C195 MM9@2:d MM9:s 0.0314026f
C196 MM9@2:d MM2:s 0.0314026f
C197 MM2@4:d vddd:265 0.00144643f
C198 MM2@4:d vddd:646 0.00180658f
C199 MM2@4:d MM2:s 0.0314026f
C200 MM2@4:d MM2@3:s 0.0314026f
C201 MM2@2:d vddd:278 0.00109715f
C202 MM2@2:d vddd:646 0.00180658f
C203 MM2@2:d MM2@3:s 0.0314026f
C204 MM2@2:d vddd:1276 0.0314026f
C205 net5:18 net8:3 0.00436982f
C206 net5:18 net8:6 0.00431203f
C207 net5:18 net8:12 0.00436982f
C208 net5:82 net8:3 0.00557466f
C209 net5:82 net8:6 0.00541934f
C210 net5:82 net8:12 0.00367761f
C211 net5:84 net8:6 0.00615307f
C212 MM7@2:d net8:6 0.00159176f
C213 MM7@2:d MM7:s 0.015476f
C214 MM7@2:d net8:51 0.015476f
C215 net5:82 net13:180 0.00775528f
C216 net5:84 net13:93 7.11487e-19
C217 net5:104 net13:123 2.63523e-19
C218 net5:143 net13:139 0.00110943f
C219 net5:155 net13:139 0.00621843f
C299 net5:180 0 9.4415e-21
C300 net5:177 0 0.00391833f
C301 net5:173 0 0.00409404f
C302 net5:169 0 0.00434605f
C303_2 net5:165 0 0.00788793f
C304_2 net5:155 0 0.0517301f
C305_2 net5:153 0 8.44216e-19
C306_2 net5:152 0 0.00137337f
C307_2 net5:148 0 0.00449166f
C308_2 net5:143 0 0.00755383f
C309_2 net5:138 0 0.00853031f
C310_2 net5:136 0 1.7802e-19
C311_2 net5:135 0 4.21678e-19
C312_2 net5:131 0 0.007454f
C313_2 net5:127 0 0.00792016f
C314_2 net5:124 0 0.00980962f
C315_2 net5:120 0 0.00352934f
C316_2 net5:115 0 0.0014572f
C317_2 net5:114 0 0.0100495f
C318_2 net5:112 0 0.0236549f
C319_2 net5:110 0 0.0404818f
C320_2 net5:106 0 0.0225436f
C321_2 net5:104 0 0.0370485f
C322_2 net5:102 0 0.00151066f
C323_2 net5:98 0 0.00214828f
C324_2 net5:96 0 0.00113945f
C325_2 net5:93 0 7.07636e-19
C326_2 net5:92 0 0.00230502f
C327_2 net5:90 0 0.00116323f
C328_2 net5:85 0 6.58672e-19
C329_2 net5:84 0 0.0280195f
C330_2 net5:82 0 0.00452649f
C331_2 net5:79 0 5.51651e-19
C332_2 net5:74 0 8.37398e-19
C333_2 net5:68 0 0.00105058f
C334_2 net5:63 0 0.00596796f
C335_2 net5:57 0 0.00625928f
C336_2 net5:47 0 0.00800697f
C337_2 net5:18 0 6.79973e-19
C338_2 net5:4 0 0.00191285f
C339_2 net5:3 0 0.00225042f
C340_2 net5:2 0 0.00236994f
C341_2 net5:1 0 0.00619978f
R342_3 net5:202 net5:214 2.25625
R343_3 net5:201 net5:214 2.25625
R344_4 net5:200 net5:209 2.25625
R345_4 net5:199 net5:209 2.25625
R346_4 net5:198 net5:204 2.25625
R347_4 net5:197 net5:204 2.25625
R348_4 net5:184 net5:194 4.0375
R349_4 net5:183 net5:194 4.0375
R350_4 net5:182 net5:190 4.0375
R351_4 net5:181 net5:190 4.0375
R352_4 net5:180 net5:186 4.0375
R353_4 net5:179 net5:186 4.0375
R354_4 net5:158 net5:161 3.2805
R355_4 net5:158 net5:159 0.439122
R356_4 net5:155 net5:159 1.9195
R357_4 net5:148 net5:161 4
R358_4 net5:148 net5:150 0.168133
R359_4 net5:143 net5:158 4
R360_4 net5:143 net5:145 0.155199
R361_4 net5:138 net5:155 4
R362_4 net5:138 net5:140 0.168133
R363_4 net5:133 net5:134 1.78006
R364_4 net5:131 net5:133 0.998444
R365_4 net5:129 net5:134 0.851132
R366_4 net5:128 net5:153 0.097173
R367_4 net5:127 net5:129 0.271525
R368_4 net5:127 net5:128 0.58408
R369_4 net5:124 net5:126 0.52134
R370_4 net5:122 net5:153 0.133675
R371_4 net5:122 net5:126 2.9626
R372_4 net5:118 net5:120 0.152985
R373_4 net5:116 net5:117 0.164877
R374_4 net5:115 net5:116 0.881686
R375_4 net5:114 net5:118 0.241705
R376_4 net5:114 net5:117 0.232898
R377_4 net5:113 net5:152 0.131543
R378_4 net5:112 net5:153 0.097173
R379_3 net5:112 net5:113 2.18335
R380_3 net5:110 net5:111 0.745809
R381_3 net5:109 net5:115 0.241705
R382_3 net5:109 net5:111 2.46305
R383_3 net5:108 net5:152 0.0899839
R384_3 net5:108 net5:110 1.80522
R385_3 net5:107 net5:145 0.0446334
R386_3 net5:106 net5:152 0.131543
R387_3 net5:106 net5:107 4.03293
R388_3 net5:105 net5:136 0.176721
R389_3 net5:104 net5:150 0.185694
R390_3 net5:104 net5:105 4.22544
R391_3 net5:100 net5:136 0.0459268
R392_3 net5:100 net5:102 0.736557
R393_3 net5:99 net5:135 0.176721
R394_3 net5:98 net5:136 0.176721
R395_3 net5:98 net5:99 0.698694
R396_3 net5:94 net5:135 0.0459268
R397_3 net5:94 net5:96 0.733134
R398_3 net5:92 net5:135 0.176721
R399_3 net5:92 net5:93 0.698694
R400_3 net5:88 net5:93 0.233181
R401_3 net5:88 net5:90 0.736557
R402_3 net5:86 net5:87 4.40998
R403_3 net5:85 net5:86 1.12444
R404_3 net5:84 net5:140 0.185694
R405_3 net5:84 net5:87 0.628363
R406_3 net5:80 net5:85 0.233181
R407_3 net5:80 net5:82 1.14785
R408_3 net5:77 net5:131 4.5
R409_3 net5:74 net5:194 40
R410_3 net5:74 net5:77 0.497966
R411_3 net5:71 net5:124 4.5
R412_3 net5:68 net5:190 40
R413_3 net5:68 net5:71 0.497966
R414_3 net5:64 net5:65 0.189732
R415_3 net5:63 net5:177 133.333
R416_3 net5:63 net5:65 0.123438
R417_3 net5:61 net5:173 133.333
R418_3 net5:61 net5:64 0.123438
R419_3 net5:59 net5:79 0.113784
R420_3 net5:59 net5:61 0.108008
R421_3 net5:57 net5:120 4.5
R422_3 net5:55 net5:79 0.115036
R423_3 net5:55 net5:57 0.03687
R424_3 net5:53 net5:54 0.189732
R425_3 net5:52 net5:169 133.333
R426_3 net5:52 net5:54 0.123438
R427_3 net5:49 net5:165 133.333
R428_3 net5:49 net5:53 0.123438
R429_3 net5:47 net5:79 0.113784
R430_3 net5:47 net5:52 0.108008
R431_3 net5:45 net5:214 90
R432_3 net5:43 net5:214 30
R433_3 net5:43 net5:45 1.6006
R434_3 net5:40 net5:102 2.25
R435_3 net5:40 net5:43 0.35569
R436_3 net5:37 net5:209 90
R437_3 net5:35 net5:209 30
R438_3 net5:35 net5:37 1.6006
R439_3 net5:32 net5:96 2.25
R440_3 net5:32 net5:35 0.35569
R441_3 net5:29 net5:204 90
R442_3 net5:27 net5:204 30
R443_3 net5:27 net5:29 1.6006
R444_3 net5:24 net5:90 2.25
R445_3 net5:24 net5:27 0.35569
R446_3 net5:21 net5:82 4.5
R447_3 net5:18 net5:186 40
R448_3 net5:18 net5:21 0.497966
R449_3 net5:15 net5:177 239.879
R450_3 net5:12 net5:173 239.879
R451_3 net5:9 net5:169 239.879
R452_2 net5:6 net5:165 239.879
R453_2 net5:4 net5:15 239.879
R454_2 net5:3 net5:12 239.879
R455_2 net5:2 net5:9 239.879
R456_2 net5:1 net5:6 239.879
** net5 2.38927e-15 *
C220 bot:405 MM6:g 0.0155342f
C221 bot:405 enableb:14 7.55916e-19
C222 bot:799 enableb:50 0.0010392f
C223 bot:823 enableb:50 0.00113838f
C224_2 bot:1486 MM6:g 5.08371e-19
C225_2 bot:1486 enableb:14 4.06285e-19
C226_2 bot:1490 enableb:50 2.09631e-19
C227_2 bot:1492 enableb:50 3.05045e-19
C228_2 bot:1496 MM6:g 2.08628e-19
C229_2 bot:1831 enableb:14 0.0030041f
C230_2 bot:403 vssd:175 0.00157054f
C231_2 bot:403 vssd:183 0.00466423f
C232_3 bot:403 vssd:326 3.73838e-19
C233_3 bot:405 vssd:11 0.015476f
C234_3 bot:405 vssd:175 4.92504e-19
C235_3 bot:405 vssd:326 5.95289e-19
C236_3 bot:805 vssd:164 0.0046528f
C237_3 bot:805 vssd:166 0.00156719f
C238_3 bot:805 vssd:173 0.0046528f
C239_3 bot:805 vssd:326 3.73838e-19
C240_3 bot:817 vssd:173 0.0046528f
C241_3 bot:817 vssd:175 0.00157054f
C242_3 bot:817 vssd:183 0.0046528f
C243_3 bot:817 vssd:326 3.73838e-19
C244_3 bot:823 vssd:140 0.00134896f
C245_3 bot:1472 vssd:164 0.00195707f
C246_3 bot:1472 vssd:173 0.00250839f
C247_3 bot:1474 vssd:173 0.00711437f
C248_3 bot:1474 vssd:175 0.00338526f
C249_3 bot:1475 vssd:164 8.04862e-19
C250_3 bot:1475 vssd:166 0.00223719f
C251_3 bot:1480 vssd:140 0.00378545f
C252_3 bot:1484 vssd:173 0.00250839f
C253_3 bot:1484 vssd:183 0.00250839f
C254_3 bot:1486 vssd:175 0.00576207f
C255_3 bot:1486 vssd:183 0.00870313f
C256_3 bot:1496 vssd:183 0.00328828f
C257_3 bot:1817 vssd:183 5.23802e-19
C258_3 bot:1831 vssd:140 0.0021913f
C259_3 MM5@4:d vssd:166 9.45002e-19
C260_3 MM5@4:d MM5:s 0.015476f
C261_3 MM5@4:d MM5@3:s 0.015476f
C262_3 MM5@4:d vssd:326 7.79607e-19
C263_3 MM5@2:d vssd:11 0.015476f
C264_3 MM5@2:d vssd:175 7.8465e-19
C265_3 MM5@2:d MM5@3:s 0.015476f
C266_2 MM5@2:d vssd:326 7.79607e-19
C267_2 Mpcap<0>:g vddd:437 0.0080317f
C268 Mpcap<0>==2:g vddd:437 0.0080317f
C269 Mpcap<0>==3:g vddd:437 0.0080317f
C270 Mpcap<0>==4:g vddd:437 0.0080317f
C271 Mpcap<0>==5:g vddd:437 0.0080317f
C272 Mpcap<0>==6:g vddd:437 0.0080317f
C273 Mpcap<0>==7:g vddd:437 0.0080317f
C274 Mpcap<0>==8:g vddd:437 0.0080317f
C275 Mpcap<0>==9:g vddd:437 0.0080317f
C276 Mpcap<0>==10:g vddd:437 0.0080317f
C277 Mpcap<0>==11:g vddd:437 0.0080317f
C278 Mpcap<0>==12:g vddd:437 0.0080317f
C279 bot:114 vddd:345 2.92413e-19
C280 bot:117 vddd:345 2.92413e-19
C281 bot:120 vddd:345 2.92413e-19
C282 bot:123 vddd:345 2.92413e-19
C283 bot:126 vddd:345 2.92413e-19
C284 bot:129 vddd:345 2.92413e-19
C285 bot:132 vddd:345 2.92413e-19
C286 bot:135 vddd:345 2.92413e-19
C287 bot:138 vddd:345 2.92413e-19
C288 bot:141 vddd:345 2.92413e-19
C289 bot:144 vddd:345 2.92413e-19
C290 bot:147 vddd:345 2.92413e-19
C291 bot:150 vddd:345 2.92415e-19
C292 bot:150 vddd:544 0.00470457f
C293 bot:302 vddd:544 0.00470457f
C294 bot:403 vddd:296 9.93253e-19
C295 bot:823 vddd:296 0.00101203f
C296 bot:835 vddd:296 0.00258937f
C297 bot:1045 vddd:544 6.57197e-19
C298 bot:1054 vddd:296 0.00251528f
C299_2 bot:1204 vddd:544 0.00406771f
C300_2 bot:1490 vddd:296 4.29542e-19
C301_2 bot:1496 vddd:296 8.40922e-19
C302_2 bot:1502 vddd:296 0.0042192f
C303_3 bot:1521 vddd:345 3.20577e-19
C304_3 bot:1545 vddd:345 3.20577e-19
C305_3 bot:1567 vddd:345 3.20577e-19
C306_3 bot:1589 vddd:345 3.20577e-19
C307_3 bot:1611 vddd:345 3.20577e-19
C308_3 bot:1633 vddd:345 3.20577e-19
C309_3 bot:1655 vddd:345 3.20577e-19
C310_3 bot:1679 vddd:345 3.20577e-19
C311_3 bot:1703 vddd:345 3.20577e-19
C312_3 bot:1727 vddd:345 3.20577e-19
C313_3 bot:1751 vddd:345 3.20577e-19
C314_3 bot:1775 vddd:345 3.20577e-19
C315_3 bot:1799 vddd:345 3.20577e-19
C316_3 bot:1799 vddd:544 0.0147718f
C317_3 bot:1817 vddd:296 0.00362282f
C318_3 bot:1822 vddd:296 0.00250085f
C319_3 bot:1827 vddd:296 5.74742e-19
C320_3 bot:1828 vddd:296 0.0476647f
C321_3 bot:1831 vddd:296 0.0188844f
C322_3 bot:1840 vddd:628 0.0289527f
C323_3 bot:799 net8:12 0.00567444f
C324_3 bot:799 net8:15 0.0041478f
C325_3 bot:799 net8:21 0.00437018f
C326_3 bot:799 net8:51 2.8998e-19
C327_3 bot:811 net8:21 0.0043601f
C328_3 bot:811 net8:24 0.0041478f
C329_3 bot:811 net8:30 0.0043601f
C330_3 bot:823 net8:30 0.00442874f
C331_3 bot:1466 net8:12 0.0020191f
C332_3 bot:1466 net8:21 0.00258164f
C333_3 bot:1468 net8:21 0.00490804f
C334_3 bot:1469 net8:15 0.00151629f
C335_3 bot:1478 net8:21 0.0024138f
C336_3 bot:1478 net8:30 0.0024138f
C337_3 bot:1480 net8:30 0.00584728f
C338_3 bot:1490 net8:30 0.00338462f
C339_3 bot:1812 net8:24 0.00127956f
C340_3 bot:1831 net8:24 2.45953e-19
C341_3 MM8:s net8:15 9.19609e-19
C342_2 MM8:s MM8@4:d 0.015476f
C343_2 MM8:s net8:51 0.00433812f
C344 MM8@3:s net8:24 0.00150696f
C345 MM8@3:s MM8@4:d 0.015476f
C346 MM8@3:s MM8@2:d 0.015476f
C347 bot:2139 MM8@2:d 0.015476f
C348 bot:805 net13:175 2.62236e-19
C349 bot:1472 net13:108 2.62236e-19
C350 bot:1472 net13:175 0.00563941f
C351 bot:1475 net13:169 3.03407e-19
C352 bot:1475 net13:171 0.00563941f
C353 bot:1484 net13:175 2.0368e-19
C354 bot:1822 net13:139 0.00223528f
C355 bot:1831 net13:133 0.00108063f
C356 bot:845 net5:68 0.0046528f
C357 bot:845 net5:124 0.00659335f
C358 bot:850 net5:68 0.0046528f
C359 bot:850 net5:74 0.0046528f
C360 bot:850 net5:124 0.0037625f
C361 bot:850 net5:131 0.0037625f
C362 bot:1051 net5:74 0.00469809f
C363 bot:1051 net5:131 0.00689751f
C364 bot:1054 net5:68 0.00211702f
C365 bot:1054 net5:74 0.00211702f
C366 bot:1054 net5:112 0.00984014f
C367 bot:1054 net5:124 0.0432281f
C368 bot:1054 net5:127 0.00230606f
C369 bot:1054 net5:131 0.0321722f
C370 bot:1054 MM10@4:d 0.00143277f
C371 bot:1054 MM10@2:d 0.00134647f
C372 bot:1466 net5:82 0.00566066f
C373 bot:1469 net5:84 0.0701995f
C374 bot:1492 net5:84 4.28858e-19
C375 bot:1511 net5:131 0.0318351f
C376 bot:1521 net5:124 4.22186e-19
C377 bot:1521 net5:131 0.00224864f
C378 bot:1822 net5:155 0.00235156f
C379 bot:1827 net5:112 0.00675137f
C380 bot:1827 net5:124 0.00329089f
C381 bot:1828 net5:84 2.87211e-19
C382 bot:1828 net5:106 0.0391255f
C383 bot:1828 net5:143 0.00337501f
C384 bot:1828 net5:155 0.0105306f
C385 bot:1831 net5:84 0.0104826f
C386 bot:1831 net5:138 0.00235156f
C387 bot:1831 net5:155 0.0271021f
C388 bot:1840 net5:110 0.0103776f
C389 bot:1840 net5:131 0.0269131f
C390 MM10:s MM10@4:d 0.015476f
C391 MM10@3:s MM10@4:d 0.015476f
C392 MM10@3:s MM10@2:d 0.015476f
C393 bot:2167 MM10@2:d 0.015476f
C394 bot:2312 net5:68 3.92469e-19
C395 bot:2312 net5:74 3.92469e-19
C396 bot:2312 MM10@4:d 9.63839e-19
C397 bot:2312 MM10@2:d 9.63839e-19
C898 bot:2312 0 0.00777184f
C899 bot:2167 0 0.0137702f
C900 bot:2139 0 0.0137294f
C901 bot:2109 0 0.0139347f
C902 bot:2105 0 9.4415e-21
C903 bot:2101 0 0.00356295f
C904 bot:2098 0 0.00348488f
C905 bot:2094 0 0.00328115f
C906 bot:2090 0 0.00328115f
C907 bot:2086 0 0.00328115f
C908 bot:2082 0 0.00328115f
C909 bot:2078 0 0.00328115f
C910 bot:2074 0 0.00328115f
C911 bot:2070 0 0.00328115f
C912 bot:2066 0 0.00328115f
C913 bot:2062 0 0.00328115f
C914 bot:2058 0 0.00328115f
C915 bot:2054 0 0.00348488f
C916 bot:2049 0 0.0200892f
C917 bot:2045 0 0.0191442f
C918 bot:2039 0 0.0172591f
C919 bot:2035 0 0.0163633f
C920 bot:2029 0 0.0172591f
C921 bot:2025 0 0.0163633f
C922 bot:2019 0 0.0172591f
C923 bot:2015 0 0.0163633f
C924 bot:2009 0 0.0172591f
C925 bot:2005 0 0.0163633f
C926 bot:1999 0 0.0172591f
C927 bot:1995 0 0.0163633f
C928 bot:1989 0 0.0172591f
C929 bot:1985 0 0.0163633f
C930 bot:1979 0 0.0172591f
C931 bot:1975 0 0.0163633f
C932 bot:1969 0 0.0172591f
C933 bot:1965 0 0.0163633f
C934 bot:1959 0 0.0172591f
C935 bot:1955 0 0.0163633f
C936 bot:1949 0 0.0172591f
C937 bot:1945 0 0.0163633f
C938 bot:1939 0 0.0200892f
C939 bot:1935 0 0.0191442f
C940 bot:1923 0 0.0469369f
C941 bot:1916 0 0.0350814f
C942 bot:1909 0 0.0351357f
C943 bot:1902 0 0.0351983f
C944 bot:1895 0 0.0351825f
C945 bot:1888 0 0.0352256f
C946 bot:1881 0 0.0352541f
C947 bot:1874 0 0.0353102f
C948 bot:1868 0 0.0353703f
C949 bot:1862 0 0.0354301f
C950 bot:1856 0 0.0354896f
C951 bot:1850 0 0.0328475f
C952 bot:1840 0 0.0638892f
C953 bot:1831 0 0.0503338f
C954 bot:1828 0 0.0331483f
C955 bot:1827 0 0.00393455f
C956 bot:1822 0 0.0103572f
C957 bot:1817 0 0.00962295f
C958 bot:1815 0 5.92866e-19
C959 bot:1814 0 1.25573e-19
C960 bot:1813 0 5.62039e-19
C961 bot:1812 0 1.37931e-19
C962 bot:1799 0 0.0263109f
C963 bot:1794 0 1.05229e-19
C964 bot:1789 0 3.98256e-19
C965 bot:1775 0 0.0111253f
C966 bot:1770 0 6.49027e-20
C967 bot:1765 0 3.98256e-19
C968 bot:1751 0 0.0109366f
C969 bot:1746 0 6.49027e-20
C970 bot:1741 0 3.98256e-19
C971 bot:1727 0 0.0110225f
C972 bot:1722 0 6.49027e-20
C973 bot:1717 0 3.98256e-19
C974 bot:1703 0 0.0111023f
C975 bot:1698 0 6.49027e-20
C976 bot:1693 0 3.98256e-19
C977 bot:1679 0 0.0111756f
C978 bot:1674 0 6.49027e-20
C979 bot:1669 0 3.98256e-19
C980 bot:1655 0 0.011242f
C981 bot:1650 0 6.49027e-20
C982 bot:1645 0 3.98256e-19
C983 bot:1633 0 0.0113024f
C984 bot:1628 0 6.49027e-20
C985 bot:1623 0 3.98256e-19
C986 bot:1611 0 0.0113588f
C987 bot:1606 0 6.49027e-20
C988 bot:1601 0 3.98256e-19
C989 bot:1589 0 0.0114106f
C990 bot:1584 0 6.49027e-20
C991 bot:1579 0 3.98256e-19
C992 bot:1567 0 0.0112518f
C993 bot:1562 0 6.49027e-20
C994 bot:1557 0 3.98256e-19
C995 bot:1545 0 0.0112859f
C996 bot:1540 0 6.49027e-20
C997 bot:1535 0 3.98256e-19
C998 bot:1521 0 0.0131432f
C999 bot:1516 0 0.00349034f
C1000 bot:1511 0 7.02368e-19
C1001 bot:1502 0 0.00621713f
C1002 bot:1498 0 0.027602f
C1003 bot:1496 0 0.00177885f
C1004 bot:1492 0 0.0224247f
C1005 bot:1490 0 0.00133387f
C1006 bot:1486 0 0.00357336f
C1007 bot:1484 0 2.37447e-19
C1008 bot:1480 0 7.40882e-19
C1009 bot:1478 0 9.46941e-19
C1010 bot:1475 0 7.89585e-19
C1011 bot:1474 0 0.003956f
C1012 bot:1472 0 2.65803e-19
C1013 bot:1469 0 5.51779e-19
C1014 bot:1468 0 0.00100947f
C1015 bot:1466 0 9.60233e-19
C1016 bot:1204 0 0.137771f
C1017 bot:1054 0 0.0149015f
C1018 bot:1051 0 0.017825f
C1019 bot:1045 0 0.0879494f
C1020 bot:850 0 0.00323032f
C1021 bot:845 0 0.00309839f
C1022 bot:840 0 0.00309453f
C1023 bot:835 0 0.0181247f
C1024 bot:823 0 0.0101598f
C1025 bot:817 0 8.97409e-19
C1026 bot:811 0 0.00116655f
C1027 bot:805 0 0.00107908f
C1028 bot:799 0 0.00397025f
C1029 bot:405 0 0.0137702f
C1030 bot:403 0 0.009917f
C1031 bot:390 0 2.91023e-19
C1032 bot:389 0 2.91023e-19
C1033 bot:388 0 2.91023e-19
C1034 bot:387 0 2.91023e-19
C1035 bot:386 0 2.91023e-19
C1036 bot:385 0 2.91023e-19
C1037 bot:384 0 2.91023e-19
C1038 bot:383 0 2.91023e-19
C1039 bot:382 0 2.91023e-19
C1040 bot:381 0 2.91023e-19
C1041 bot:380 0 2.91023e-19
C1042 bot:379 0 0.0621741f
C1043 bot:377 0 0.062372f
C1044 bot:302 0 0.034849f
C1045 bot:266 0 0.037695f
C1046 bot:238 0 4.55571e-19
C1047 bot:237 0 4.55571e-19
C1048 bot:236 0 4.55571e-19
C1049 bot:235 0 4.55571e-19
C1050 bot:234 0 4.55571e-19
C1051 bot:233 0 4.55571e-19
C1052 bot:232 0 4.55571e-19
C1053 bot:231 0 4.55571e-19
C1054 bot:230 0 4.55571e-19
C1055 bot:229 0 4.55571e-19
C1056 bot:228 0 4.55571e-19
C1057 bot:227 0 0.0625365f
C1058 bot:225 0 0.0625365f
C1059 bot:150 0 0.0348533f
C1060 bot:147 0 4.33203e-21
C1061 bot:144 0 4.33203e-21
C1062 bot:141 0 4.33203e-21
C1063 bot:138 0 4.33203e-21
C1064 bot:135 0 4.33203e-21
C1065 bot:132 0 4.33203e-21
C1066 bot:129 0 4.33203e-21
C1067 bot:126 0 4.33203e-21
C1068 bot:123 0 4.33203e-21
C1069 bot:120 0 4.33203e-21
C1070 bot:117 0 4.33203e-21
C1071 bot:114 0 0.0480043f
C1072 bot:62 0 0.0616236f
C1073 bot:61 0 0.0388347f
C1074 bot:60 0 0.0388347f
C1075 bot:59 0 0.0388347f
C1076 bot:58 0 0.0388347f
C1077 bot:57 0 0.0388347f
C1078 bot:56 0 0.0388347f
C1079 bot:55 0 0.0388347f
C1080 bot:54 0 0.0388347f
C1081 bot:53 0 0.0388347f
C1082 bot:52 0 0.0388347f
C1083 bot:51 0 0.0616236f
C1084 bot:13 0 0.0412663f
C1085 bot:12 0 0.019858f
C1086 bot:11 0 0.019858f
C1087 bot:10 0 0.019858f
C1088 bot:9 0 0.019858f
C1089 bot:8 0 0.019858f
C1090 bot:7 0 0.019858f
C1091 bot:6 0 0.019858f
C1092 bot:5 0 0.019858f
C1093 bot:4 0 0.019858f
C1094 bot:3 0 0.019858f
C1095 bot:2 0 0.0418849f
R1096 bot:2310 bot:2312 10.45
R1097 bot:2308 bot:2310 15.675
R1098 bot:2306 bot:2308 15.675
R1099 bot:2304 bot:2306 15.675
R1100 bot:2302 bot:2304 15.675
R1101 bot:2300 bot:2302 15.675
R1102 bot:2298 bot:2300 15.675
R1103 bot:2296 bot:2298 15.675
R1104 bot:2294 bot:2296 15.675
R1105 bot:2292 bot:2294 15.675
R1106 bot:2290 bot:2292 15.675
R1107 bot:2288 bot:2290 15.675
R1108 bot:2286 bot:2288 15.675
R1109 bot:2284 bot:2286 15.675
R1110 bot:2282 bot:2284 15.675
R1111 bot:2280 bot:2282 15.675
R1112 bot:2278 bot:2280 15.675
R1113 bot:2276 bot:2278 15.675
R1114 bot:2274 bot:2276 15.675
R1115 bot:2267 bot:2269 15.675
R1116 bot:2265 bot:2267 15.675
R1117 bot:2263 bot:2265 15.675
R1118 bot:2261 bot:2263 15.675
R1119 bot:2259 bot:2261 15.675
R1120 bot:2257 bot:2259 15.675
R1121 bot:2255 bot:2257 15.675
R1122 bot:2253 bot:2255 15.675
R1123 bot:2251 bot:2253 15.675
R1124 bot:2249 bot:2251 15.675
R1125 bot:2247 bot:2249 15.675
R1126 bot:2245 bot:2247 15.675
R1127 bot:2243 bot:2245 15.675
R1128 bot:2241 bot:2243 16.302
R1129 bot:2239 bot:2241 16.302
R1130 bot:2237 bot:2239 16.302
R1131 bot:2235 bot:2237 16.302
R1132 bot:2233 bot:2235 16.302
R1133 bot:2230 bot:2233 16.302
R1134 bot:2164 bot:2167 1.0625
R1135 bot:2146 bot:2149 1.0625
R1136 bot:2136 bot:2139 1.0625
R1137 bot:2118 bot:2121 1.0625
R1138 bot:2116 bot:2164 2.975
R1139 bot:2115 bot:2160 4.0375
R1140 bot:2114 bot:2160 4.0375
R1141 bot:2113 bot:2156 4.0375
R1142 bot:2112 bot:2156 4.0375
R1143 bot:2111 bot:2152 4.0375
R1144 bot:2110 bot:2152 4.0375
R1145 bot:2109 bot:2149 2.975
R1146 bot:2108 bot:2136 2.975
R1147 bot:2107 bot:2132 4.0375
R1148 bot:2106 bot:2132 4.0375
R1149 bot:2105 bot:2128 4.0375
R1150 bot:2104 bot:2128 4.0375
R1151 bot:2103 bot:2124 4.0375
R1152 bot:2102 bot:2124 4.0375
R1153 bot:2101 bot:2121 2.975
R1154 bot:1926 bot:1927 4.0556
R1155 bot:1923 bot:1927 4.48199
R1156 bot:1919 bot:1920 4.0556
R1157 bot:1916 bot:1920 4.46482
R1158 bot:1912 bot:1913 4.0556
R1159 bot:1909 bot:1913 4.46732
R1160 bot:1905 bot:1906 4.0556
R1161 bot:1902 bot:1906 4.50269
R1162 bot:1898 bot:1899 4.0556
R1163 bot:1895 bot:1899 4.52859
R1164 bot:1891 bot:1892 4.0556
R1165 bot:1888 bot:1892 4.52859
R1166 bot:1884 bot:1885 4.0556
R1167 bot:1881 bot:1885 4.50533
R1168 bot:1877 bot:1878 4.0556
R1169 bot:1874 bot:1878 4.47774
R1170 bot:1868 bot:1871 8.4862
R1171 bot:1862 bot:1865 8.4862
R1172 bot:1856 bot:1859 8.4862
R1173 bot:1850 bot:1853 8.4862
R1174 bot:1846 bot:1847 1.37782
R1175 bot:1845 bot:1846 1.6528
R1176 bot:1844 bot:1845 1.51801
R1177 bot:1843 bot:1847 1.04168
R1178 bot:1840 bot:1844 3.0417
R1179 bot:1836 bot:1837 1.59958
R1180 bot:1834 bot:1837 0.52953
R1181 bot:1831 bot:1834 3.00928
R1182 bot:1827 bot:1828 0.209329
R1183 bot:1822 bot:1836 4
R1184 bot:1822 bot:1824 0.129333
R1185 bot:1817 bot:1831 4
R1186 bot:1817 bot:1819 0.168133
R1187 bot:1808 bot:1810 1.78001
R1188 bot:1805 bot:1806 0.46551
R1189 bot:1804 bot:1808 1.39739
R1190 bot:1804 bot:1806 1.56374
R1191 bot:1802 bot:1805 0.86505
R1192 bot:1799 bot:1802 1.39739
R1193 bot:1794 bot:1926 8
R1194 bot:1789 bot:1923 2.25
R1195 bot:1784 bot:1786 1.78001
R1196 bot:1781 bot:1782 0.459813
R1197 bot:1780 bot:1784 1.39739
R1198 bot:1780 bot:1782 1.56374
R1199 bot:1778 bot:1781 0.86505
R1200 bot:1775 bot:1778 1.39739
R1201 bot:1770 bot:1919 8
R1202 bot:1765 bot:1916 2.25
R1203 bot:1760 bot:1762 1.78001
R1204 bot:1757 bot:1758 0.459708
R1205 bot:1756 bot:1760 1.39739
R1206 bot:1756 bot:1758 1.56374
R1207 bot:1754 bot:1757 0.86505
R1208 bot:1751 bot:1754 1.39739
R1209 bot:1746 bot:1912 8
R1210 bot:1741 bot:1909 2.25
R1211 bot:1736 bot:1738 1.78001
R1212 bot:1733 bot:1734 0.463595
R1213 bot:1732 bot:1736 1.39739
R1214 bot:1732 bot:1734 1.56374
R1215 bot:1730 bot:1733 0.86505
R1216 bot:1727 bot:1730 1.39739
R1217 bot:1722 bot:1905 8
R1218 bot:1717 bot:1902 2.25
R1219 bot:1712 bot:1714 1.78001
R1220 bot:1709 bot:1710 0.460693
R1221 bot:1708 bot:1712 1.39739
R1222 bot:1708 bot:1710 1.56374
R1223 bot:1706 bot:1709 0.86505
R1224 bot:1703 bot:1706 1.39739
R1225 bot:1698 bot:1898 8
R1226 bot:1693 bot:1895 2.25
R1227 bot:1688 bot:1690 1.78001
R1228 bot:1685 bot:1686 0.458302
R1229 bot:1684 bot:1688 1.39739
R1230 bot:1684 bot:1686 1.56374
R1231 bot:1682 bot:1685 0.86505
R1232 bot:1679 bot:1682 1.39739
R1233 bot:1674 bot:1891 8
R1234 bot:1669 bot:1888 2.25
R1235 bot:1664 bot:1666 1.78001
R1236 bot:1661 bot:1662 0.459917
R1237 bot:1660 bot:1664 1.39739
R1238 bot:1660 bot:1662 1.56374
R1239 bot:1658 bot:1661 0.86505
R1240 bot:1655 bot:1658 1.39739
R1241 bot:1650 bot:1884 8
R1242 bot:1645 bot:1881 2.25
R1243 bot:1640 bot:1642 1.78001
R1244 bot:1638 bot:1640 1.39739
R1245 bot:1636 bot:1638 2.89459
R1246 bot:1633 bot:1636 1.39739
R1247 bot:1628 bot:1877 8
R1248 bot:1623 bot:1874 2.25
R1249 bot:1618 bot:1620 1.78001
R1250 bot:1616 bot:1618 1.39739
R1251 bot:1614 bot:1616 2.89459
R1252 bot:1611 bot:1614 1.39739
R1253 bot:1606 bot:1871 8
R1254 bot:1601 bot:1868 2.25
R1255 bot:1596 bot:1598 1.78001
R1256 bot:1594 bot:1596 1.39739
R1257 bot:1592 bot:1594 2.89459
R1258 bot:1589 bot:1592 1.39739
R1259 bot:1584 bot:1865 8
R1260 bot:1579 bot:1862 2.25
R1261 bot:1574 bot:1576 1.78001
R1262 bot:1572 bot:1574 1.39739
R1263 bot:1570 bot:1572 2.89459
R1264 bot:1567 bot:1570 1.39739
R1265 bot:1562 bot:1859 8
R1266 bot:1557 bot:1856 2.25
R1267 bot:1552 bot:1554 1.78001
R1268 bot:1550 bot:1552 1.39739
R1269 bot:1548 bot:1550 2.89459
R1270 bot:1545 bot:1548 1.39739
R1271 bot:1540 bot:1853 8
R1272 bot:1535 bot:1850 2.25
R1273 bot:1530 bot:1532 1.78001
R1274 bot:1527 bot:1528 0.46551
R1275 bot:1526 bot:1530 1.39739
R1276 bot:1526 bot:1528 1.56374
R1277 bot:1524 bot:1527 0.86505
R1278 bot:1521 bot:1524 1.39739
R1279 bot:1516 bot:1843 8
R1280 bot:1511 bot:1840 2.25
R1281 bot:1509 bot:1828 1.2144
R1282 bot:1508 bot:1509 0.367016
R1283 bot:1507 bot:1508 3.9323
R1284 bot:1506 bot:1507 0.364015
R1285 bot:1505 bot:1824 0.185694
R1286 bot:1505 bot:1506 0.627846
R1287 bot:1502 bot:1834 4
R1288 bot:1500 bot:1502 0.349199
R1289 bot:1499 bot:1815 0.176721
R1290 bot:1498 bot:1819 0.185694
R1291 bot:1498 bot:1499 1.78001
R1292 bot:1494 bot:1815 0.0459268
R1293 bot:1494 bot:1496 0.621981
R1294 bot:1493 bot:1814 0.176721
R1295 bot:1492 bot:1500 0.27861
R1296 bot:1492 bot:1493 2.20507
R1297 bot:1488 bot:1814 0.0459268
R1298 bot:1488 bot:1490 0.55651
R1299 bot:1487 bot:1813 0.176721
R1300 bot:1486 bot:1815 0.176721
R1301 bot:1486 bot:1487 0.698694
R1302 bot:1482 bot:1813 0.0459268
R1303 bot:1482 bot:1484 0.619091
R1304 bot:1481 bot:1812 0.176721
R1305 bot:1480 bot:1814 0.176721
R1306 bot:1480 bot:1481 0.696337
R1307 bot:1476 bot:1812 0.0459268
R1308 bot:1476 bot:1478 0.553923
R1309 bot:1474 bot:1813 0.176721
R1310 bot:1474 bot:1475 0.698694
R1311 bot:1470 bot:1475 0.233181
R1312 bot:1470 bot:1472 0.619091
R1313 bot:1468 bot:1812 0.176721
R1314 bot:1468 bot:1469 0.696337
R1315 bot:1464 bot:1469 0.233181
R1316 bot:1464 bot:1466 0.55651
R1317 bot:1463 bot:1511 2.25
R1318 bot:1460 bot:1461 0.0334095
R1319 bot:1459 bot:1463 0.00652387
R1320 bot:1459 bot:1461 0.0685007
R1321 bot:1458 bot:1460 0.0685007
R1322 bot:1456 bot:1457 0.0334095
R1323 bot:1455 bot:2233 30
R1324 bot:1455 bot:1458 0.0326194
R1325 bot:1455 bot:1457 0.0358813
R1326 bot:1452 bot:1453 0.0334095
R1327 bot:1451 bot:1456 0.0685007
R1328 bot:1451 bot:1453 0.0685007
R1329 bot:1450 bot:2230 30
R1330 bot:1450 bot:1452 0.0163097
R1331 bot:1447 bot:1448 0.0334095
R1332 bot:1446 bot:1450 0.052191
R1333 bot:1446 bot:1448 0.0685007
R1334 bot:1445 bot:1827 2
R1335 bot:1445 bot:1447 0.0424052
R1336 bot:1442 bot:1445 0.0260955
R1337 bot:1439 bot:1808 4.5
R1338 bot:1436 bot:1804 1.5
R1339 bot:1430 bot:1802 4.5
R1340 bot:1427 bot:1799 1.5
R1341 bot:1421 bot:1784 4.5
R1342 bot:1418 bot:1780 1.5
R1343 bot:1412 bot:1778 4.5
R1344 bot:1409 bot:1775 1.5
R1345 bot:1403 bot:1760 4.5
R1346 bot:1400 bot:1756 1.5
R1347 bot:1394 bot:1754 4.5
R1348 bot:1391 bot:1751 1.5
R1349 bot:1385 bot:1736 4.5
R1350 bot:1382 bot:1732 1.5
R1351 bot:1376 bot:1730 4.5
R1352 bot:1373 bot:1727 1.5
R1353 bot:1367 bot:1712 4.5
R1354 bot:1364 bot:1708 1.5
R1355 bot:1358 bot:1706 4.5
R1356 bot:1355 bot:1703 1.5
R1357 bot:1349 bot:1688 4.5
R1358 bot:1346 bot:1684 1.5
R1359 bot:1340 bot:1682 4.5
R1360 bot:1337 bot:1679 1.5
R1361 bot:1331 bot:1664 4.5
R1362 bot:1328 bot:1660 1.5
R1363 bot:1322 bot:1658 4.5
R1364 bot:1319 bot:1655 1.5
R1365 bot:1313 bot:1640 4.5
R1366 bot:1310 bot:1638 1.5
R1367 bot:1304 bot:1636 4.5
R1368 bot:1301 bot:1633 1.5
R1369 bot:1295 bot:1618 4.5
R1370 bot:1292 bot:1616 1.5
R1371 bot:1286 bot:1614 4.5
R1372 bot:1283 bot:1611 1.5
R1373 bot:1277 bot:1596 4.5
R1374 bot:1274 bot:1594 1.5
R1375 bot:1268 bot:1592 4.5
R1376 bot:1265 bot:1589 1.5
R1377 bot:1259 bot:1574 4.5
R1378 bot:1256 bot:1572 1.5
R1379 bot:1250 bot:1570 4.5
R1380 bot:1247 bot:1567 1.5
R1381 bot:1241 bot:1552 4.5
R1382 bot:1238 bot:1550 1.5
R1383 bot:1232 bot:1548 4.5
R1384 bot:1229 bot:1545 1.5
R1385 bot:1223 bot:1530 4.5
R1386 bot:1220 bot:1526 1.5
R1387 bot:1214 bot:1524 4.5
R1388 bot:1211 bot:1521 1.5
R1389 bot:1204 bot:1810 2.25
R1390 bot:1204 bot:1205 0.0166908
R1391 bot:1202 bot:2312 90
R1392 bot:1202 bot:1205 0.114168
R1393 bot:1200 bot:2310 30
R1394 bot:1200 bot:1202 0.163097
R1395 bot:1198 bot:1789 2.25
R1396 bot:1198 bot:1200 0.0163097
R1397 bot:1195 bot:2308 30
R1398 bot:1195 bot:1198 0.228336
R1399 bot:1195 bot:1196 0.176145
R1400 bot:1192 bot:1786 2.25
R1401 bot:1192 bot:1196 0.0166908
R1402 bot:1192 bot:1193 0.0166908
R1403 bot:1190 bot:2306 30
R1404 bot:1190 bot:1193 0.0358813
R1405 bot:1188 bot:2304 30
R1406 bot:1188 bot:1190 0.244645
R1407 bot:1186 bot:1765 2.25
R1408 bot:1186 bot:1188 0.0293574
R1409 bot:1183 bot:2302 30
R1410 bot:1183 bot:1186 0.215288
R1411 bot:1183 bot:1184 0.172883
R1412 bot:1180 bot:1762 2.25
R1413 bot:1180 bot:1184 0.0166908
R1414 bot:1180 bot:1181 0.0166908
R1415 bot:1178 bot:2300 30
R1416 bot:1178 bot:1181 0.0391432
R1417 bot:1176 bot:2298 30
R1418 bot:1176 bot:1178 0.244645
R1419 bot:1174 bot:1741 2.25
R1420 bot:1174 bot:1176 0.0424052
R1421 bot:1171 bot:2296 30
R1422 bot:1171 bot:1174 0.20224
R1423 bot:1171 bot:1172 0.169621
R1424 bot:1168 bot:1738 2.25
R1425 bot:1168 bot:1172 0.0166908
R1426 bot:1168 bot:1169 0.0166908
R1427 bot:1166 bot:2294 30
R1428 bot:1166 bot:1169 0.0424052
R1429 bot:1164 bot:2292 30
R1430 bot:1164 bot:1166 0.244645
R1431 bot:1162 bot:1717 2.25
R1432 bot:1162 bot:1164 0.0554529
R1433 bot:1159 bot:2290 30
R1434 bot:1159 bot:1162 0.189192
R1435 bot:1159 bot:1160 0.166359
R1436 bot:1156 bot:1714 2.25
R1437 bot:1156 bot:1160 0.0166908
R1438 bot:1156 bot:1157 0.0166908
R1439 bot:1154 bot:2288 30
R1440 bot:1154 bot:1157 0.0456671
R1441 bot:1152 bot:2286 30
R1442 bot:1152 bot:1154 0.244645
R1443 bot:1150 bot:1693 2.25
R1444 bot:1150 bot:1152 0.0685007
R1445 bot:1147 bot:2284 30
R1446 bot:1147 bot:1150 0.176145
R1447 bot:1147 bot:1148 0.163097
R1448 bot:1144 bot:1690 2.25
R1449 bot:1144 bot:1148 0.0166908
R1450 bot:1144 bot:1145 0.0166908
R1451 bot:1142 bot:2282 30
R1452 bot:1142 bot:1145 0.0489291
R1453 bot:1140 bot:2280 30
R1454 bot:1140 bot:1142 0.244645
R1455 bot:1138 bot:1669 2.25
R1456 bot:1138 bot:1140 0.0815484
R1457 bot:1135 bot:2278 30
R1458 bot:1135 bot:1138 0.163097
R1459 bot:1135 bot:1136 0.159835
R1460 bot:1132 bot:1666 2.25
R1461 bot:1132 bot:1136 0.0166908
R1462 bot:1132 bot:1133 0.0166908
R1463 bot:1130 bot:2276 30
R1464 bot:1130 bot:1133 0.052191
R1465 bot:1128 bot:2274 30
R1466 bot:1128 bot:1130 0.244645
R1467 bot:1126 bot:1645 2.25
R1468 bot:1126 bot:1128 0.0945962
R1469 bot:1123 bot:2269 30
R1470 bot:1123 bot:1126 0.150049
R1471 bot:1123 bot:1124 0.156573
R1472 bot:1120 bot:1642 2.25
R1473 bot:1120 bot:1124 0.0166908
R1474 bot:1120 bot:1121 0.0166908
R1475 bot:1118 bot:2267 30
R1476 bot:1118 bot:1121 0.0554529
R1477 bot:1116 bot:2265 30
R1478 bot:1116 bot:1118 0.244645
R1479 bot:1114 bot:1623 2.25
R1480 bot:1114 bot:1116 0.107644
R1481 bot:1111 bot:2263 30
R1482 bot:1111 bot:1114 0.137001
R1483 bot:1111 bot:1112 0.153311
R1484 bot:1108 bot:1620 2.25
R1485 bot:1108 bot:1112 0.0166908
R1486 bot:1108 bot:1109 0.0166908
R1487 bot:1106 bot:2261 30
R1488 bot:1106 bot:1109 0.0587149
R1489 bot:1104 bot:2259 30
R1490 bot:1104 bot:1106 0.244645
R1491 bot:1102 bot:1601 2.25
R1492 bot:1102 bot:1104 0.120692
R1493 bot:1099 bot:2257 30
R1494 bot:1099 bot:1102 0.123954
R1495 bot:1099 bot:1100 0.150049
R1496 bot:1096 bot:1598 2.25
R1497 bot:1096 bot:1100 0.0166908
R1498 bot:1096 bot:1097 0.0166908
R1499 bot:1094 bot:2255 30
R1500 bot:1094 bot:1097 0.0619768
R1501 bot:1092 bot:2253 30
R1502 bot:1092 bot:1094 0.244645
R1503 bot:1090 bot:1579 2.25
R1504 bot:1090 bot:1092 0.133739
R1505 bot:1087 bot:2251 30
R1506 bot:1087 bot:1090 0.110906
R1507 bot:1087 bot:1088 0.146787
R1508 bot:1084 bot:1576 2.25
R1509 bot:1084 bot:1088 0.0166908
R1510 bot:1084 bot:1085 0.0166908
R1511 bot:1082 bot:2249 30
R1512 bot:1082 bot:1085 0.0652387
R1513 bot:1080 bot:2247 30
R1514 bot:1080 bot:1082 0.244645
R1515 bot:1078 bot:1557 2.25
R1516 bot:1078 bot:1080 0.146787
R1517 bot:1075 bot:2245 30
R1518 bot:1075 bot:1078 0.0978581
R1519 bot:1075 bot:1076 0.143525
R1520 bot:1072 bot:1554 2.25
R1521 bot:1072 bot:1076 0.0166908
R1522 bot:1072 bot:1073 0.0166908
R1523 bot:1070 bot:2243 30
R1524 bot:1070 bot:1073 0.0685007
R1525 bot:1068 bot:2241 30
R1526 bot:1068 bot:1070 0.254431
R1527 bot:1066 bot:1535 2.25
R1528 bot:1066 bot:1068 0.150049
R1529 bot:1063 bot:2239 30
R1530 bot:1063 bot:1066 0.104382
R1531 bot:1063 bot:1064 0.120692
R1532 bot:1060 bot:1532 2.25
R1533 bot:1060 bot:1064 0.0166908
R1534 bot:1060 bot:1061 0.0166908
R1535 bot:1058 bot:2237 30
R1536 bot:1058 bot:1061 0.10112
R1537 bot:1056 bot:2235 30
R1538 bot:1056 bot:1058 0.254431
R1539 bot:1054 bot:1463 0.00978581
R1540 bot:1054 bot:1056 0.0358813
R1541 bot:1051 bot:2167 40
R1542 bot:1051 bot:1053 0.745274
R1543 bot:1049 bot:1459 0.52908
R1544 bot:1049 bot:1053 0.683331
R1545 bot:1045 bot:2049 444.444
R1546 bot:1045 bot:2098 51.2821
R1547 bot:1045 bot:2045 444.444
R1548 bot:1043 bot:1794 8
R1549 bot:1043 bot:1045 0.666957
R1550 bot:1039 bot:2049 444.444
R1551 bot:1039 bot:2098 51.2821
R1552 bot:1039 bot:2045 444.444
R1553 bot:1039 bot:1043 0.20615
R1554 bot:1034 bot:1035 0.154385
R1555 bot:1033 bot:2049 444.444
R1556 bot:1033 bot:2098 51.2821
R1557 bot:1033 bot:2045 444.444
R1558 bot:1033 bot:1039 0.873108
R1559 bot:1033 bot:1035 0.424427
R1560 bot:1029 bot:2039 444.444
R1561 bot:1029 bot:2094 51.2821
R1562 bot:1029 bot:2035 444.444
R1563 bot:1029 bot:1034 0.424427
R1564 bot:1027 bot:1770 8
R1565 bot:1027 bot:1029 0.72759
R1566 bot:1023 bot:2039 444.444
R1567 bot:1023 bot:2094 51.2821
R1568 bot:1023 bot:2035 444.444
R1569 bot:1023 bot:1027 0.145518
R1570 bot:1018 bot:1019 0.154385
R1571 bot:1017 bot:2039 444.444
R1572 bot:1017 bot:2094 51.2821
R1573 bot:1017 bot:2035 444.444
R1574 bot:1017 bot:1023 0.873108
R1575 bot:1017 bot:1019 0.424427
R1576 bot:1013 bot:2029 444.444
R1577 bot:1013 bot:2090 51.2821
R1578 bot:1013 bot:2025 444.444
R1579 bot:1013 bot:1018 0.424427
R1580 bot:1011 bot:1746 8
R1581 bot:1011 bot:1013 0.788222
R1582 bot:1007 bot:2029 444.444
R1583 bot:1007 bot:2090 51.2821
R1584 bot:1007 bot:2025 444.444
R1585 bot:1007 bot:1011 0.0848855
R1586 bot:1002 bot:1003 0.154385
R1587 bot:1001 bot:2029 444.444
R1588 bot:1001 bot:2090 51.2821
R1589 bot:1001 bot:2025 444.444
R1590 bot:1001 bot:1007 0.873108
R1591 bot:1001 bot:1003 0.424427
R1592 bot:997 bot:2019 444.444
R1593 bot:997 bot:2086 51.2821
R1594 bot:997 bot:2015 444.444
R1595 bot:997 bot:1002 0.424427
R1596 bot:995 bot:1722 8
R1597 bot:995 bot:997 0.848855
R1598 bot:991 bot:2019 444.444
R1599 bot:991 bot:2086 51.2821
R1600 bot:991 bot:2015 444.444
R1601 bot:991 bot:995 0.024253
R1602 bot:986 bot:987 0.154385
R1603 bot:985 bot:2019 444.444
R1604 bot:985 bot:2086 51.2821
R1605 bot:985 bot:2015 444.444
R1606 bot:985 bot:991 0.873108
R1607 bot:985 bot:987 0.424427
R1608 bot:981 bot:2009 444.444
R1609 bot:981 bot:2082 51.2821
R1610 bot:981 bot:2005 444.444
R1611 bot:981 bot:986 0.424427
R1612 bot:977 bot:2009 444.444
R1613 bot:977 bot:2082 51.2821
R1614 bot:977 bot:2005 444.444
R1615 bot:977 bot:981 0.873108
R1616 bot:975 bot:1698 8
R1617 bot:975 bot:977 0.0363795
R1618 bot:970 bot:971 0.154385
R1619 bot:969 bot:2009 444.444
R1620 bot:969 bot:2082 51.2821
R1621 bot:969 bot:2005 444.444
R1622 bot:969 bot:975 0.836728
R1623 bot:969 bot:971 0.424427
R1624 bot:965 bot:1999 444.444
R1625 bot:965 bot:2078 51.2821
R1626 bot:965 bot:1995 444.444
R1627 bot:965 bot:970 0.424427
R1628 bot:961 bot:1999 444.444
R1629 bot:961 bot:2078 51.2821
R1630 bot:961 bot:1995 444.444
R1631 bot:961 bot:965 0.873108
R1632 bot:959 bot:1674 8
R1633 bot:959 bot:961 0.097012
R1634 bot:954 bot:955 0.154385
R1635 bot:953 bot:1999 444.444
R1636 bot:953 bot:2078 51.2821
R1637 bot:953 bot:1995 444.444
R1638 bot:953 bot:959 0.776096
R1639 bot:953 bot:955 0.424427
R1640 bot:949 bot:1989 444.444
R1641 bot:949 bot:2074 51.2821
R1642 bot:949 bot:1985 444.444
R1643 bot:949 bot:954 0.424427
R1644 bot:945 bot:1989 444.444
R1645 bot:945 bot:2074 51.2821
R1646 bot:945 bot:1985 444.444
R1647 bot:945 bot:949 0.873108
R1648 bot:943 bot:1650 8
R1649 bot:943 bot:945 0.157644
R1650 bot:938 bot:939 0.154385
R1651 bot:937 bot:1989 444.444
R1652 bot:937 bot:2074 51.2821
R1653 bot:937 bot:1985 444.444
R1654 bot:937 bot:943 0.715463
R1655 bot:937 bot:939 0.424427
R1656 bot:933 bot:1979 444.444
R1657 bot:933 bot:2070 51.2821
R1658 bot:933 bot:1975 444.444
R1659 bot:933 bot:938 0.424427
R1660 bot:929 bot:1979 444.444
R1661 bot:929 bot:2070 51.2821
R1662 bot:929 bot:1975 444.444
R1663 bot:929 bot:933 0.873108
R1664 bot:927 bot:1628 8
R1665 bot:927 bot:929 0.218277
R1666 bot:922 bot:923 0.154385
R1667 bot:921 bot:1979 444.444
R1668 bot:921 bot:2070 51.2821
R1669 bot:921 bot:1975 444.444
R1670 bot:921 bot:927 0.654831
R1671 bot:921 bot:923 0.424427
R1672 bot:917 bot:1969 444.444
R1673 bot:917 bot:2066 51.2821
R1674 bot:917 bot:1965 444.444
R1675 bot:917 bot:922 0.424427
R1676 bot:913 bot:1969 444.444
R1677 bot:913 bot:2066 51.2821
R1678 bot:913 bot:1965 444.444
R1679 bot:913 bot:917 0.873108
R1680 bot:911 bot:1606 8
R1681 bot:911 bot:913 0.278909
R1682 bot:906 bot:907 0.154385
R1683 bot:905 bot:1969 444.444
R1684 bot:905 bot:2066 51.2821
R1685 bot:905 bot:1965 444.444
R1686 bot:905 bot:911 0.594198
R1687 bot:905 bot:907 0.424427
R1688 bot:901 bot:1959 444.444
R1689 bot:901 bot:2062 51.2821
R1690 bot:901 bot:1955 444.444
R1691 bot:901 bot:906 0.424427
R1692 bot:897 bot:1959 444.444
R1693 bot:897 bot:2062 51.2821
R1694 bot:897 bot:1955 444.444
R1695 bot:897 bot:901 0.873108
R1696 bot:895 bot:1584 8
R1697 bot:895 bot:897 0.339542
R1698 bot:890 bot:891 0.154385
R1699 bot:889 bot:1959 444.444
R1700 bot:889 bot:2062 51.2821
R1701 bot:889 bot:1955 444.444
R1702 bot:889 bot:895 0.533566
R1703 bot:889 bot:891 0.424427
R1704 bot:885 bot:1949 444.444
R1705 bot:885 bot:2058 51.2821
R1706 bot:885 bot:1945 444.444
R1707 bot:885 bot:890 0.424427
R1708 bot:881 bot:1949 444.444
R1709 bot:881 bot:2058 51.2821
R1710 bot:881 bot:1945 444.444
R1711 bot:881 bot:885 0.873108
R1712 bot:879 bot:1562 8
R1713 bot:879 bot:881 0.400174
R1714 bot:874 bot:875 0.154385
R1715 bot:873 bot:1949 444.444
R1716 bot:873 bot:2058 51.2821
R1717 bot:873 bot:1945 444.444
R1718 bot:873 bot:879 0.472933
R1719 bot:873 bot:875 0.424427
R1720 bot:869 bot:1939 444.444
R1721 bot:869 bot:2054 51.2821
R1722 bot:869 bot:1935 444.444
R1723 bot:869 bot:874 0.424427
R1724 bot:865 bot:1939 444.444
R1725 bot:865 bot:2054 51.2821
R1726 bot:865 bot:1935 444.444
R1727 bot:865 bot:869 0.873108
R1728 bot:863 bot:1540 8
R1729 bot:863 bot:865 0.460807
R1730 bot:858 bot:859 0.154385
R1731 bot:857 bot:1939 444.444
R1732 bot:857 bot:2054 51.2821
R1733 bot:857 bot:1935 444.444
R1734 bot:857 bot:863 0.412301
R1735 bot:857 bot:859 0.424427
R1736 bot:854 bot:1516 8
R1737 bot:854 bot:858 1.49156
R1738 bot:850 bot:2160 40
R1739 bot:850 bot:852 1.38719
R1740 bot:848 bot:1458 0.52908
R1741 bot:848 bot:852 0.689764
R1742 bot:845 bot:2156 40
R1743 bot:845 bot:847 1.38719
R1744 bot:843 bot:1451 0.52908
R1745 bot:843 bot:847 0.689764
R1746 bot:840 bot:2152 40
R1747 bot:840 bot:842 1.38719
R1748 bot:838 bot:1446 0.52908
R1749 bot:838 bot:842 0.689764
R1750 bot:835 bot:2146 40
R1751 bot:835 bot:837 0.745274
R1752 bot:833 bot:1442 0.52908
R1753 bot:833 bot:837 0.683331
R1754 bot:831 bot:1496 4.5
R1755 bot:826 bot:1490 4.5
R1756 bot:823 bot:2139 40
R1757 bot:823 bot:826 0.267534
R1758 bot:820 bot:1484 4.5
R1759 bot:817 bot:2132 40
R1760 bot:817 bot:820 0.426828
R1761 bot:814 bot:1478 4.5
R1762 bot:811 bot:2128 40
R1763 bot:811 bot:814 0.497966
R1764 bot:808 bot:1472 4.5
R1765 bot:805 bot:2124 40
R1766 bot:805 bot:808 0.426828
R1767 bot:802 bot:1466 4.5
R1768 bot:799 bot:2118 40
R1769 bot:799 bot:802 0.28405
R1770 bot:739 bot:2098 0.951472
R1771 bot:739 bot:2049 0.109785
R1772 bot:738 bot:2098 0.951472
R1773 bot:738 bot:2045 0.109785
R1774 bot:737 bot:2094 0.951472
R1775 bot:737 bot:2039 0.109785
R1776 bot:736 bot:2094 0.951472
R1777 bot:736 bot:2035 0.109785
R1778 bot:735 bot:2090 0.951472
R1779 bot:735 bot:2029 0.109785
R1780 bot:734 bot:2090 0.951472
R1781 bot:734 bot:2025 0.109785
R1782 bot:733 bot:2086 0.951472
R1783 bot:733 bot:2019 0.109785
R1784 bot:732 bot:2086 0.951472
R1785 bot:732 bot:2015 0.109785
R1786 bot:731 bot:2082 0.951472
R1787 bot:731 bot:2009 0.109785
R1788 bot:730 bot:2082 0.951472
R1789 bot:730 bot:2005 0.109785
R1790 bot:729 bot:2078 0.951472
R1791 bot:729 bot:1999 0.109785
R1792 bot:728 bot:2078 0.951472
R1793 bot:728 bot:1995 0.109785
R1794 bot:727 bot:2074 0.951472
R1795 bot:727 bot:1989 0.109785
R1796 bot:726 bot:2074 0.951472
R1797 bot:726 bot:1985 0.109785
R1798 bot:725 bot:2070 0.951472
R1799 bot:725 bot:1979 0.109785
R1800 bot:724 bot:2070 0.951472
R1801 bot:724 bot:1975 0.109785
R1802 bot:723 bot:2066 0.951472
R1803 bot:723 bot:1969 0.109785
R1804 bot:722 bot:2066 0.951472
R1805 bot:722 bot:1965 0.109785
R1806 bot:721 bot:2062 0.951472
R1807 bot:721 bot:1959 0.109785
R1808 bot:720 bot:2062 0.951472
R1809 bot:720 bot:1955 0.109785
R1810 bot:719 bot:2058 0.951472
R1811 bot:719 bot:1949 0.109785
R1812 bot:718 bot:2058 0.951472
R1813 bot:718 bot:1945 0.109785
R1814 bot:717 bot:2054 0.951472
R1815 bot:717 bot:1939 0.109785
R1816 bot:716 bot:2054 0.951472
R1817 bot:716 bot:1935 0.109785
R1818 bot:405 bot:407 1.0625
R1819 bot:404 bot:407 2.975
R1820 bot:403 bot:831 0.229315
R1821 bot:403 bot:405 40
R1822 bot:377 bot:391 0.23375
R1823 bot:329 bot:379 0.23188
R1824 bot:326 bot:391 0.8415
R1825 bot:325 bot:390 1.07525
R1826 bot:324 bot:390 1.07525
R1827 bot:323 bot:389 1.07525
R1828 bot:322 bot:389 1.07525
R1829 bot:321 bot:388 1.07525
R1830 bot:320 bot:388 1.07525
R1831 bot:319 bot:387 1.07525
R1832 bot:318 bot:387 1.07525
R1833 bot:317 bot:386 1.07525
R1834 bot:316 bot:386 1.07525
R1835 bot:315 bot:385 1.07525
R1836 bot:314 bot:385 1.07525
R1837 bot:313 bot:384 1.07525
R1838 bot:312 bot:384 1.07525
R1839 bot:311 bot:383 1.07525
R1840 bot:310 bot:383 1.07525
R1841 bot:309 bot:382 1.07525
R1842 bot:308 bot:382 1.07525
R1843 bot:307 bot:381 1.07525
R1844 bot:306 bot:381 1.07525
R1845 bot:305 bot:380 1.07525
R1846 bot:304 bot:380 1.07525
R1847 bot:303 bot:379 0.8415
R1848 bot:302 bot:1436 0.879556
R1849 bot:302 bot:377 26.6667
R1850 bot:301 bot:1439 1.16637
R1851 bot:301 bot:1436 0.439778
R1852 bot:301 bot:377 26.6667
R1853 bot:300 bot:1439 0.0956039
R1854 bot:300 bot:377 26.6667
R1855 bot:299 bot:1418 0.879556
R1856 bot:299 bot:390 26.6667
R1857 bot:298 bot:1421 1.16637
R1858 bot:298 bot:1418 0.439778
R1859 bot:298 bot:390 26.6667
R1860 bot:297 bot:1421 0.0956039
R1861 bot:297 bot:390 26.6667
R1862 bot:296 bot:1400 0.879556
R1863 bot:296 bot:389 26.6667
R1864 bot:295 bot:1403 1.16637
R1865 bot:295 bot:1400 0.439778
R1866 bot:295 bot:389 26.6667
R1867 bot:294 bot:1403 0.0956039
R1868 bot:294 bot:389 26.6667
R1869 bot:293 bot:1382 0.879556
R1870 bot:293 bot:388 26.6667
R1871 bot:292 bot:1385 1.16637
R1872 bot:292 bot:1382 0.439778
R1873 bot:292 bot:388 26.6667
R1874 bot:291 bot:1385 0.0956039
R1875 bot:291 bot:388 26.6667
R1876 bot:290 bot:1364 0.879556
R1877 bot:290 bot:387 26.6667
R1878 bot:289 bot:1367 1.16637
R1879 bot:289 bot:1364 0.439778
R1880 bot:289 bot:387 26.6667
R1881 bot:288 bot:1367 0.0956039
R1882 bot:288 bot:387 26.6667
R1883 bot:287 bot:1346 0.879556
R1884 bot:287 bot:386 26.6667
R1885 bot:286 bot:1349 1.16637
R1886 bot:286 bot:1346 0.439778
R1887 bot:286 bot:386 26.6667
R1888 bot:285 bot:1349 0.0956039
R1889 bot:285 bot:386 26.6667
R1890 bot:284 bot:1328 0.879556
R1891 bot:284 bot:385 26.6667
R1892 bot:283 bot:1331 1.16637
R1893 bot:283 bot:1328 0.439778
R1894 bot:283 bot:385 26.6667
R1895 bot:282 bot:1331 0.0956039
R1896 bot:282 bot:385 26.6667
R1897 bot:281 bot:1310 0.879556
R1898 bot:281 bot:384 26.6667
R1899 bot:280 bot:1313 1.16637
R1900 bot:280 bot:1310 0.439778
R1901 bot:280 bot:384 26.6667
R1902 bot:279 bot:1313 0.0956039
R1903 bot:279 bot:384 26.6667
R1904 bot:278 bot:1292 0.879556
R1905 bot:278 bot:383 26.6667
R1906 bot:277 bot:1295 1.16637
R1907 bot:277 bot:1292 0.439778
R1908 bot:277 bot:383 26.6667
R1909 bot:276 bot:1295 0.0956039
R1910 bot:276 bot:383 26.6667
R1911 bot:275 bot:1274 0.879556
R1912 bot:275 bot:382 26.6667
R1913 bot:274 bot:1277 1.16637
R1914 bot:274 bot:1274 0.439778
R1915 bot:274 bot:382 26.6667
R1916 bot:273 bot:1277 0.0956039
R1917 bot:273 bot:382 26.6667
R1918 bot:272 bot:1256 0.879556
R1919 bot:272 bot:381 26.6667
R1920 bot:271 bot:1259 1.16637
R1921 bot:271 bot:1256 0.439778
R1922 bot:271 bot:381 26.6667
R1923 bot:270 bot:1259 0.0956039
R1924 bot:270 bot:381 26.6667
R1925 bot:269 bot:1238 0.879556
R1926 bot:269 bot:380 26.6667
R1927 bot:268 bot:1241 1.16637
R1928 bot:268 bot:1238 0.439778
R1929 bot:268 bot:380 26.6667
R1930 bot:267 bot:1241 0.0956039
R1931 bot:267 bot:380 26.6667
R1932 bot:266 bot:1220 0.879556
R1933 bot:266 bot:329 26.6667
R1934 bot:265 bot:1223 1.16637
R1935 bot:265 bot:1220 0.439778
R1936 bot:265 bot:329 26.6667
R1937 bot:264 bot:1223 0.0956039
R1938 bot:264 bot:329 26.6667
R1939 bot:225 bot:239 0.23375
R1940 bot:177 bot:227 0.23188
R1941 bot:174 bot:239 0.8415
R1942 bot:173 bot:238 1.07525
R1943 bot:172 bot:238 1.07525
R1944 bot:171 bot:237 1.07525
R1945 bot:170 bot:237 1.07525
R1946 bot:169 bot:236 1.07525
R1947 bot:168 bot:236 1.07525
R1948 bot:167 bot:235 1.07525
R1949 bot:166 bot:235 1.07525
R1950 bot:165 bot:234 1.07525
R1951 bot:164 bot:234 1.07525
R1952 bot:163 bot:233 1.07525
R1953 bot:162 bot:233 1.07525
R1954 bot:161 bot:232 1.07525
R1955 bot:160 bot:232 1.07525
R1956 bot:159 bot:231 1.07525
R1957 bot:158 bot:231 1.07525
R1958 bot:157 bot:230 1.07525
R1959 bot:156 bot:230 1.07525
R1960 bot:155 bot:229 1.07525
R1961 bot:154 bot:229 1.07525
R1962 bot:153 bot:228 1.07525
R1963 bot:152 bot:228 1.07525
R1964 bot:151 bot:227 0.8415
R1965 bot:150 bot:1427 0.879556
R1966 bot:150 bot:225 26.6667
R1967 bot:149 bot:1430 1.16637
R1968 bot:149 bot:1427 0.439778
R1969 bot:149 bot:225 26.6667
R1970 bot:148 bot:1430 0.0956039
R1971 bot:148 bot:225 26.6667
R1972 bot:147 bot:1409 0.879556
R1973 bot:147 bot:238 26.6667
R1974 bot:146 bot:1412 1.16637
R1975 bot:146 bot:1409 0.439778
R1976 bot:146 bot:238 26.6667
R1977 bot:145 bot:1412 0.0956039
R1978 bot:145 bot:238 26.6667
R1979 bot:144 bot:1391 0.879556
R1980 bot:144 bot:237 26.6667
R1981 bot:143 bot:1394 1.16637
R1982 bot:143 bot:1391 0.439778
R1983 bot:143 bot:237 26.6667
R1984 bot:142 bot:1394 0.0956039
R1985 bot:142 bot:237 26.6667
R1986 bot:141 bot:1373 0.879556
R1987 bot:141 bot:236 26.6667
R1988 bot:140 bot:1376 1.16637
R1989 bot:140 bot:1373 0.439778
R1990 bot:140 bot:236 26.6667
R1991 bot:139 bot:1376 0.0956039
R1992 bot:139 bot:236 26.6667
R1993 bot:138 bot:1355 0.879556
R1994 bot:138 bot:235 26.6667
R1995 bot:137 bot:1358 1.16637
R1996 bot:137 bot:1355 0.439778
R1997 bot:137 bot:235 26.6667
R1998 bot:136 bot:1358 0.0956039
R1999 bot:136 bot:235 26.6667
R2000 bot:135 bot:1337 0.879556
R2001 bot:135 bot:234 26.6667
R2002 bot:134 bot:1340 1.16637
R2003 bot:134 bot:1337 0.439778
R2004 bot:134 bot:234 26.6667
R2005 bot:133 bot:1340 0.0956039
R2006 bot:133 bot:234 26.6667
R2007 bot:132 bot:1319 0.879556
R2008 bot:132 bot:233 26.6667
R2009 bot:131 bot:1322 1.16637
R2010 bot:131 bot:1319 0.439778
R2011 bot:131 bot:233 26.6667
R2012 bot:130 bot:1322 0.0956039
R2013 bot:130 bot:233 26.6667
R2014 bot:129 bot:1301 0.879556
R2015 bot:129 bot:232 26.6667
R2016 bot:128 bot:1304 1.16637
R2017 bot:128 bot:1301 0.439778
R2018 bot:128 bot:232 26.6667
R2019 bot:127 bot:1304 0.0956039
R2020 bot:127 bot:232 26.6667
R2021 bot:126 bot:1283 0.879556
R2022 bot:126 bot:231 26.6667
R2023 bot:125 bot:1286 1.16637
R2024 bot:125 bot:1283 0.439778
R2025 bot:125 bot:231 26.6667
R2026 bot:124 bot:1286 0.0956039
R2027 bot:124 bot:231 26.6667
R2028 bot:123 bot:1265 0.879556
R2029 bot:123 bot:230 26.6667
R2030 bot:122 bot:1268 1.16637
R2031 bot:122 bot:1265 0.439778
R2032 bot:122 bot:230 26.6667
R2033 bot:121 bot:1268 0.0956039
R2034 bot:121 bot:230 26.6667
R2035 bot:120 bot:1247 0.879556
R2036 bot:120 bot:229 26.6667
R2037 bot:119 bot:1250 1.16637
R2038 bot:119 bot:1247 0.439778
R2039 bot:119 bot:229 26.6667
R2040 bot:118 bot:1250 0.0956039
R2041 bot:118 bot:229 26.6667
R2042 bot:117 bot:1229 0.879556
R2043 bot:117 bot:228 26.6667
R2044 bot:116 bot:1232 1.16637
R2045 bot:116 bot:1229 0.439778
R2046 bot:116 bot:228 26.6667
R2047 bot:115 bot:1232 0.0956039
R2048 bot:115 bot:228 26.6667
R2049 bot:114 bot:1211 0.879556
R2050 bot:114 bot:177 26.6667
R2051 bot:113 bot:1214 1.16637
R2052 bot:113 bot:1211 0.439778
R2053 bot:113 bot:177 26.6667
R2054 bot:112 bot:1214 0.0956039
R2055 bot:112 bot:177 26.6667
R2056 bot:100 bot:2274 15.048
R2057 bot:100 bot:2269 0.627
R2058 bot:96 bot:2049 9.25855
R2059 bot:93 bot:2039 9.25855
R2060 bot:90 bot:2029 9.25855
R2061 bot:87 bot:2019 9.25855
R2062 bot:84 bot:2009 9.25855
R2063 bot:81 bot:1999 9.25855
R2064 bot:78 bot:1989 9.25855
R2065 bot:75 bot:1979 9.25855
R2066 bot:72 bot:1969 9.25855
R2067 bot:69 bot:1959 9.25855
R2068 bot:66 bot:1949 9.25855
R2069 bot:63 bot:1939 9.25855
R2070 bot:62 bot:96 36.5951
R2071 bot:61 bot:93 36.5951
R2072 bot:60 bot:90 36.5951
R2073 bot:59 bot:87 36.5951
R2074 bot:58 bot:84 36.5951
R2075 bot:57 bot:81 36.5951
R2076 bot:56 bot:78 36.5951
R2077 bot:55 bot:75 36.5951
R2078 bot:54 bot:72 36.5951
R2079 bot:53 bot:69 36.5951
R2080 bot:52 bot:66 36.5951
R2081 bot:51 bot:63 36.5951
R2082 bot:48 bot:2045 9.25855
R2083 bot:45 bot:2035 9.25855
R2084 bot:42 bot:2025 9.25855
R2085 bot:39 bot:2015 9.25855
R2086 bot:36 bot:2005 9.25855
R2087 bot:33 bot:1995 9.25855
R2088 bot:30 bot:1985 9.25855
R2089 bot:27 bot:1975 9.25855
R2090 bot:24 bot:1965 9.25855
R2091 bot:21 bot:1955 9.25855
R2092 bot:18 bot:1945 9.25855
R2093 bot:15 bot:1935 9.25855
R2094 bot:13 bot:48 36.5951
R2095 bot:12 bot:45 36.5951
R2096 bot:11 bot:42 36.5951
R2097 bot:10 bot:39 36.5951
R2098 bot:9 bot:36 36.5951
R2099 bot:8 bot:33 36.5951
R2100 bot:7 bot:30 36.5951
R2101 bot:6 bot:27 36.5951
R2102 bot:5 bot:24 36.5951
R2103 bot:4 bot:21 36.5951
R2104 bot:3 bot:18 36.5951
R2105 bot:2 bot:15 36.5951
** bot 1.95392e-14 *
C398 in vssd:111 0.135801f
C399 in vddd:345 0.136417f
C400 in:16 vddd:296 7.7857e-19
C401 in:19 vddd:296 0.00101505f
C402 in:8 net5:124 2.62236e-19
C403 in:27 net5:68 2.62236e-19
C404 in:27 net5:112 9.94258e-19
C405 in:27 net5:124 0.00692177f
C406 in:29 net5:124 8.89973e-19
C407 in:2 bot:835 0.00466584f
C408 in:2 bot:840 0.0046528f
C409 in:2 bot:1054 0.00222529f
C410 in:2 bot:2312 3.92469e-19
C411 in:8 bot:840 0.0046528f
C412 in:8 bot:845 0.0046528f
C413 in:8 bot:1054 0.00221949f
C414 in:8 bot:2312 3.92469e-19
C415 in bot:114 0.00388773f
C416 in bot:266 6.77885e-19
C417 in bot:1521 0.00875088f
C418 in:16 bot:835 0.00620468f
C419 in:16 bot:840 0.00230822f
C420 in:16 bot:1054 5.69346e-19
C421 in:16 bot:1827 0.0018345f
C422 in:27 bot:840 0.00230822f
C423 in:27 bot:845 0.00230822f
C424 in:27 bot:1054 0.00104391f
C425 MM11@4:d bot:1054 0.00131626f
C426 MM11@4:d MM11:s 0.015476f
C427 MM11@4:d MM11@3:s 0.015476f
C428 MM11@4:d bot:2312 9.58344e-19
C429 MM11@2:d bot:1054 0.00131626f
C430 MM11@2:d MM11@3:s 0.015476f
C431 MM11@2:d MM10:s 0.015476f
C432 MM11@2:d bot:2312 9.63839e-19
C67_2 in:29 0 0.0027893f
C68_2 in:27 0 0.00486106f
C69_2 in:19 0 0.00174587f
C70_2 in:18 0 0.00446219f
C71_2 in:16 0 0.00613798f
C72_2 in:13 0 0.239333f
C73_2 in:8 0 0.00101906f
C74_2 in:2 0 8.37398e-19
R75 in:33 in:39 4.0375
R76 in:32 in:39 4.0375
R77 in:31 in:35 4.0375
R78 in:30 in:35 4.0375
R79 in:26 in:27 0.391005
R80 in:24 in:29 0.0568578
R81 in:24 in:27 0.900236
R82 in:20 in:29 0.0568578
R83 in:20 in:23 0.0642024
R84 in:18 in:29 0.210629
R85 in:18 in:19 0.598881
R86 in:14 in:19 0.233181
R87 in:14 in:16 1.29307
R88 in:13 in:23 4.50453
R89 in:11 in:26 4.5
R90 in:8 in:39 40
R91 in:8 in:11 0.497966
R92 in:5 in:16 4.5
R93 in:2 in:35 40
R94 in:2 in:5 0.497966
** in 8.5201e-16 *
C433 top:16 vddd:628 0.0015276f
C434 top:52 vddd:544 0.00470457f
C435 top:168 vddd:437 2.59762e-19
C436 top:171 vddd:437 2.59762e-19
C437 top:174 vddd:437 2.59762e-19
C438 top:177 vddd:437 2.59762e-19
C439 top:180 vddd:437 2.59762e-19
C440 top:183 vddd:437 2.59762e-19
C441 top:186 vddd:437 2.59762e-19
C442 top:189 vddd:437 2.59762e-19
C443 top:192 vddd:437 2.59762e-19
C444 top:195 vddd:437 2.59762e-19
C445 top:198 vddd:437 2.59762e-19
C446 top:201 vddd:437 2.59762e-19
C447 top:204 vddd:437 2.59764e-19
C448 top:204 vddd:544 0.00470457f
C449 Mncap<1>:g vddd:345 0.00768435f
C450 Mncap<1>==2:g vddd:345 0.00768435f
C451 Mncap<1>==3:g vddd:345 0.00768435f
C452 Mncap<1>==4:g vddd:345 0.00768435f
C453 Mncap<1>==5:g vddd:345 0.00768435f
C454 Mncap<1>==6:g vddd:345 0.00768435f
C455 Mncap<1>==7:g vddd:345 0.00768435f
C456 Mncap<1>==8:g vddd:345 0.00768435f
C457 Mncap<1>==9:g vddd:345 0.00768435f
C458 Mncap<1>==10:g vddd:345 0.00768435f
C459 Mncap<1>==11:g vddd:345 0.00768435f
C460 Mncap<1>==12:g vddd:345 0.00768435f
C461 top:716 vddd:296 0.00247739f
C462 top:716 vddd:326 8.3868e-19
C463 top:726 vddd:530 0.0043601f
C464 top:726 vddd:610 3.31744e-19
C465 top:726 vddd:616 0.00317106f
C466 top:731 vddd:530 0.0043601f
C467 top:731 vddd:536 0.0043601f
C468 top:731 vddd:616 0.00256479f
C469 top:731 vddd:628 0.00256479f
C470 top:736 vddd:536 0.00457484f
C471 top:736 vddd:628 0.00349284f
C472 top:738 vddd:296 0.00242507f
C473 top:738 vddd:530 0.00127333f
C474 top:738 vddd:536 0.00127161f
C475 top:738 vddd:616 9.11581e-19
C476 top:738 vddd:628 9.11581e-19
C477 top:866 vddd:544 0.00406771f
C478 top:990 vddd:544 6.57415e-19
C479 top:1247 vddd:437 2.21919e-19
C480 top:1247 vddd:616 4.59545e-19
C481 top:1247 vddd:628 0.0059228f
C482 top:1269 vddd:437 2.21919e-19
C483 top:1291 vddd:437 2.21919e-19
C484 top:1313 vddd:437 2.21919e-19
C485 top:1335 vddd:437 2.21919e-19
C486 top:1357 vddd:437 2.21919e-19
C487 top:1379 vddd:437 2.21919e-19
C488 top:1402 vddd:437 2.21919e-19
C489 top:1425 vddd:437 2.21919e-19
C490 top:1448 vddd:437 2.21919e-19
C491 top:1471 vddd:437 2.21919e-19
C492 top:1494 vddd:437 2.21919e-19
C493 top:1517 vddd:437 2.21919e-19
C494 top:1517 vddd:544 0.0158757f
C495 top:1612 vddd:544 0.0062685f
C496 MM0:s MM0@4:d 0.0154144f
C497 MM0@3:s MM0@4:d 0.0154144f
C498 MM0@3:s MM0@2:d 0.0154144f
C499 top:1807 MM0@2:d 0.0154144f
C500 top:716 MM1:g 6.53023e-19
C501 top:716 net5:110 0.0154155f
C502 top:716 net5:114 0.00120719f
C503 top:721 MM1@4:g 6.53023e-19
C504 top:721 MM1@3:g 6.53023e-19
C505 top:721 net5:57 5.45805e-19
C506 top:721 net5:79 0.00537479f
C507 top:721 net5:120 9.889e-19
C508 top:726 MM1@2:g 6.53023e-19
C509 top:738 net5:47 6.43165e-19
C510 top:738 net5:63 6.87717e-19
C511 top:738 net5:110 0.0149313f
C512 top:738 net5:112 0.0156414f
C513 top:738 net5:114 3.64035e-19
C514 top:872 net5:131 0.0053604f
C515 top:1775 MM1:g 9.95058e-19
C516 top:1775 MM1@4:g 9.95058e-19
C517 top:1775 MM1@3:g 9.95058e-19
C518 top:1775 MM1@2:g 9.95058e-19
C519 MM1:s MM1:g 0.0121529f
C520 MM1:s net5:47 8.48483e-19
C521 MM1@3:s MM1@4:g 0.0121529f
C522 MM1@3:s MM1@3:g 0.0121529f
C523 MM1@3:s net5:47 0.00107575f
C524 MM1@3:s net5:79 0.00236556f
C525 MM0:s MM1@2:g 0.0121529f
C526 MM0:s net5:63 8.5192e-19
C527 top:16 bot:1045 0.00406601f
C528 top:19 bot:1045 0.00406601f
C529 top:22 bot:1045 0.00406601f
C530 top:25 bot:1045 0.00406601f
C531 top:28 bot:1045 0.00406601f
C532 top:31 bot:1045 0.00406601f
C533 top:34 bot:1045 0.00406601f
C534 top:37 bot:1045 0.00406601f
C535 top:40 bot:1045 0.00406601f
C536 top:43 bot:1045 0.00406601f
C537 top:46 bot:1045 0.00406601f
C538 top:49 bot:1045 0.00406601f
C539 top:127 Mpcap<1>==12:g 0.101233f
C540 top:129 Mpcap<1>:g 0.101233f
C541 top:129 bot:1045 0.00296791f
C542 top:130 Mpcap<1>:g 0.101233f
C543 top:130 Mpcap<1>==2:g 0.101233f
C544 top:130 bot:1045 0.00405502f
C545 top:131 Mpcap<1>==2:g 0.101233f
C546 top:131 Mpcap<1>==3:g 0.101233f
C547 top:131 bot:1045 0.00405502f
C548 top:132 Mpcap<1>==3:g 0.101233f
C549 top:132 Mpcap<1>==4:g 0.101233f
C550 top:132 bot:1045 0.00405502f
C551 top:133 Mpcap<1>==4:g 0.101233f
C552 top:133 Mpcap<1>==5:g 0.101233f
C553 top:133 bot:1045 0.00405502f
C554 top:134 Mpcap<1>==5:g 0.101233f
C555 top:134 Mpcap<1>==6:g 0.101233f
C556 top:134 bot:1045 0.00405502f
C557 top:135 Mpcap<1>==6:g 0.101233f
C558 top:135 Mpcap<1>==7:g 0.101233f
C559 top:135 bot:1045 0.00405502f
C560 top:136 Mpcap<1>==7:g 0.101233f
C561 top:136 Mpcap<1>==8:g 0.101233f
C562 top:136 bot:1045 0.00405502f
C563 top:137 Mpcap<1>==8:g 0.101233f
C564 top:137 Mpcap<1>==9:g 0.101233f
C565 top:137 bot:1045 0.00405502f
C566 top:138 Mpcap<1>==9:g 0.101233f
C567 top:138 Mpcap<1>==10:g 0.101233f
C568 top:138 bot:1045 0.00405502f
C569 top:139 Mpcap<1>==10:g 0.101233f
C570 top:139 Mpcap<1>==11:g 0.101233f
C571 top:139 bot:1045 0.00405502f
C572 top:140 Mpcap<1>==11:g 0.101233f
C573 top:140 Mpcap<1>==12:g 0.101233f
C574 top:140 bot:1045 0.00405502f
C575 top:168 bot:1045 0.00404523f
C576 top:171 bot:1045 0.00404523f
C577 top:174 bot:1045 0.00404523f
C578 top:177 bot:1045 0.00404523f
C579 top:180 bot:1045 0.00404523f
C580 top:183 bot:1045 0.00404523f
C581 top:186 bot:1045 0.00404523f
C582 top:189 bot:1045 0.00404523f
C583 top:192 bot:1045 0.00404523f
C584 top:195 bot:1045 0.00404523f
C585 top:198 bot:1045 0.00404523f
C586 top:201 bot:1045 0.00404523f
C587 top:279 Mpcap<0>==12:g 0.101233f
C588 top:281 Mpcap<0>:g 0.101233f
C589 top:281 bot:1045 0.00296791f
C590 top:282 Mpcap<0>:g 0.101233f
C591 top:282 Mpcap<0>==2:g 0.101233f
C592 top:282 bot:1045 0.00405502f
C593 top:283 Mpcap<0>==2:g 0.101233f
C594 top:283 Mpcap<0>==3:g 0.101233f
C595 top:283 bot:1045 0.00405502f
C596 top:284 Mpcap<0>==3:g 0.101233f
C597 top:284 Mpcap<0>==4:g 0.101233f
C598 top:284 bot:1045 0.00405502f
C599 top:285 Mpcap<0>==4:g 0.101233f
C600 top:285 Mpcap<0>==5:g 0.101233f
C601 top:285 bot:1045 0.00405502f
C602 top:286 Mpcap<0>==5:g 0.101233f
C603 top:286 Mpcap<0>==6:g 0.101233f
C604 top:286 bot:1045 0.00405502f
C605 top:287 Mpcap<0>==6:g 0.101233f
C606 top:287 Mpcap<0>==7:g 0.101233f
C607 top:287 bot:1045 0.00405502f
C608 top:288 Mpcap<0>==7:g 0.101233f
C609 top:288 Mpcap<0>==8:g 0.101233f
C610 top:288 bot:1045 0.00405502f
C611 top:289 Mpcap<0>==8:g 0.101233f
C612 top:289 Mpcap<0>==9:g 0.101233f
C613 top:289 bot:1045 0.00405502f
C614 top:290 Mpcap<0>==9:g 0.101233f
C615 top:290 Mpcap<0>==10:g 0.101233f
C616 top:290 bot:1045 0.00405502f
C617 top:291 Mpcap<0>==10:g 0.101233f
C618 top:291 Mpcap<0>==11:g 0.101233f
C619 top:291 bot:1045 0.00405502f
C620 top:292 Mpcap<0>==11:g 0.101233f
C621 top:292 Mpcap<0>==12:g 0.101233f
C622 top:292 bot:1045 0.00405502f
C623 Mncap<1>:g bot:227 0.104201f
C624 Mncap<1>:g bot:228 0.104201f
C625 Mncap<1>==2:g bot:228 0.104201f
C626 Mncap<1>==2:g bot:229 0.104201f
C627 Mncap<1>==3:g bot:229 0.104201f
C628 Mncap<1>==3:g bot:230 0.104201f
C629 Mncap<1>==4:g bot:230 0.104201f
C630 Mncap<1>==4:g bot:231 0.104201f
C631 Mncap<1>==5:g bot:231 0.104201f
C632 Mncap<1>==5:g bot:232 0.104201f
C633 Mncap<1>==6:g bot:232 0.104201f
C634 Mncap<1>==6:g bot:233 0.104201f
C635 Mncap<1>==7:g bot:233 0.104201f
C636 Mncap<1>==7:g bot:234 0.104201f
C637 Mncap<1>==8:g bot:234 0.104201f
C638 Mncap<1>==8:g bot:235 0.104201f
C639 Mncap<1>==9:g bot:235 0.104201f
C640 Mncap<1>==9:g bot:236 0.104201f
C641 Mncap<1>==10:g bot:236 0.104201f
C642 Mncap<1>==10:g bot:237 0.104201f
C643 Mncap<1>==11:g bot:237 0.104201f
C644 Mncap<1>==11:g bot:238 0.104201f
C645 Mncap<1>==12:g bot:225 0.104201f
C646 Mncap<1>==12:g bot:238 0.104201f
C647 Mncap<0>:g bot:379 0.104201f
C648 Mncap<0>:g bot:380 0.104201f
C649 Mncap<0>:g bot:1204 0.0528178f
C650 Mncap<0>:g bot:1521 7.12928e-19
C651 Mncap<0>:g bot:1545 7.12928e-19
C652 Mncap<0>:g bot:2312 0.0252246f
C653 Mncap<0>==2:g bot:380 0.104201f
C654 Mncap<0>==2:g bot:381 0.104201f
C655 Mncap<0>==2:g bot:1204 0.0528178f
C656 Mncap<0>==2:g bot:1545 7.12928e-19
C657 Mncap<0>==2:g bot:1567 7.12928e-19
C658 Mncap<0>==2:g bot:2312 0.0252246f
C659 Mncap<0>==3:g bot:381 0.104201f
C660 Mncap<0>==3:g bot:382 0.104201f
C661 Mncap<0>==3:g bot:1204 0.0528178f
C662 Mncap<0>==3:g bot:1567 7.12928e-19
C663 Mncap<0>==3:g bot:1589 7.12928e-19
C664 Mncap<0>==3:g bot:2312 0.0252246f
C665 Mncap<0>==4:g bot:382 0.104201f
C666 Mncap<0>==4:g bot:383 0.104201f
C667 Mncap<0>==4:g bot:1204 0.0528178f
C668 Mncap<0>==4:g bot:1589 7.12928e-19
C669 Mncap<0>==4:g bot:1611 7.12928e-19
C670 Mncap<0>==4:g bot:2312 0.0252246f
C671 Mncap<0>==5:g bot:383 0.104201f
C672 Mncap<0>==5:g bot:384 0.104201f
C673 Mncap<0>==5:g bot:1204 0.0528178f
C674 Mncap<0>==5:g bot:1611 7.12928e-19
C675 Mncap<0>==5:g bot:1633 7.12928e-19
C676 Mncap<0>==5:g bot:2312 0.0252246f
C677 Mncap<0>==6:g bot:384 0.104201f
C678 Mncap<0>==6:g bot:385 0.104201f
C679 Mncap<0>==6:g bot:1204 0.0528178f
C680 Mncap<0>==6:g bot:1633 7.12928e-19
C681 Mncap<0>==6:g bot:1655 7.12928e-19
C682 Mncap<0>==6:g bot:2312 0.0252246f
C683 Mncap<0>==7:g bot:385 0.104201f
C684 Mncap<0>==7:g bot:386 0.104201f
C685 Mncap<0>==7:g bot:1204 0.0528178f
C686 Mncap<0>==7:g bot:1655 7.12928e-19
C687 Mncap<0>==7:g bot:1679 7.12928e-19
C688 Mncap<0>==7:g bot:2312 0.0252246f
C689 Mncap<0>==8:g bot:386 0.104201f
C690 Mncap<0>==8:g bot:387 0.104201f
C691 Mncap<0>==8:g bot:1204 0.0528178f
C692 Mncap<0>==8:g bot:1679 7.12928e-19
C693 Mncap<0>==8:g bot:1703 7.12928e-19
C694 Mncap<0>==8:g bot:2312 0.0252246f
C695 Mncap<0>==9:g bot:387 0.104201f
C696 Mncap<0>==9:g bot:388 0.104201f
C697 Mncap<0>==9:g bot:1204 0.0528178f
C698 Mncap<0>==9:g bot:1703 7.12928e-19
C699 Mncap<0>==9:g bot:1727 7.12928e-19
C700 Mncap<0>==9:g bot:2312 0.0252246f
C701 Mncap<0>==10:g bot:388 0.104201f
C702 Mncap<0>==10:g bot:389 0.104201f
C703 Mncap<0>==10:g bot:1204 0.0528178f
C704 Mncap<0>==10:g bot:1727 7.12928e-19
C705 Mncap<0>==10:g bot:1751 7.12928e-19
C706 Mncap<0>==10:g bot:2312 0.0252246f
C707 Mncap<0>==11:g bot:389 0.104201f
C708 Mncap<0>==11:g bot:390 0.104201f
C709 Mncap<0>==11:g bot:1204 0.0528178f
C710 Mncap<0>==11:g bot:1751 7.12928e-19
C711 Mncap<0>==11:g bot:1775 7.12928e-19
C712 Mncap<0>==11:g bot:2312 0.0252246f
C713 Mncap<0>==12:g bot:377 0.104201f
C714 Mncap<0>==12:g bot:390 0.104201f
C715 Mncap<0>==12:g bot:1204 0.0528178f
C716 Mncap<0>==12:g bot:1775 7.12928e-19
C717 Mncap<0>==12:g bot:1799 7.12928e-19
C718 Mncap<0>==12:g bot:2312 0.0252246f
C719 top:731 bot:1840 0.00304633f
C720 top:736 bot:1840 0.0101622f
C721 top:738 bot:1054 0.0372873f
C722 top:738 bot:1511 2.15886e-19
C723 top:738 bot:1840 0.0138519f
C724 top:742 bot:1204 4.35586e-19
C725 top:742 bot:1840 0.0326797f
C726 top:866 Mpcap<1>:g 0.0352664f
C727 top:866 Mpcap<1>==2:g 0.0352664f
C728 top:866 Mpcap<1>==3:g 0.0352664f
C729 top:866 Mpcap<1>==4:g 0.0352664f
C730 top:866 Mpcap<1>==5:g 0.0352664f
C731 top:866 Mpcap<1>==6:g 0.0352664f
C732 top:866 Mpcap<1>==7:g 0.0352664f
C733 top:866 Mpcap<1>==8:g 0.0352664f
C734 top:866 Mpcap<1>==9:g 0.0352664f
C735 top:866 Mpcap<1>==10:g 0.0352664f
C736 top:866 Mpcap<1>==11:g 0.0352664f
C737 top:866 Mpcap<1>==12:g 0.0352664f
C738 top:866 bot:1204 0.0372873f
C739 top:866 bot:1535 2.08684e-19
C740 top:866 bot:1557 2.08684e-19
C741 top:866 bot:1579 2.08684e-19
C742 top:866 bot:1601 2.08684e-19
C743 top:866 bot:1623 2.08684e-19
C744 top:866 bot:1645 2.08684e-19
C745 top:866 bot:1669 2.08684e-19
C746 top:866 bot:1693 2.08684e-19
C747 top:866 bot:1717 2.08684e-19
C748 top:866 bot:1741 2.08684e-19
C749 top:866 bot:1765 2.08684e-19
C750 top:866 bot:1789 2.08684e-19
C751 top:866 bot:1840 0.00501758f
C752 top:866 bot:1850 0.0199464f
C753 top:866 bot:1856 0.0207247f
C754 top:866 bot:1862 0.0208512f
C755 top:866 bot:1868 0.0209461f
C756 top:866 bot:1874 0.0210109f
C757 top:866 bot:1881 0.0210577f
C758 top:866 bot:1888 0.0210898f
C759 top:866 bot:1895 0.0211193f
C760 top:866 bot:1902 0.0211587f
C761 top:866 bot:1909 0.021209f
C762 top:866 bot:1916 0.0212036f
C763 top:866 bot:1923 0.0211773f
C764 top:872 bot:1051 0.00703847f
C765 top:872 bot:1204 0.0187126f
C766 top:872 bot:1511 0.00243874f
C767 top:872 bot:1521 0.0434295f
C768 top:872 bot:1840 0.0277907f
C769 top:872 bot:1850 0.0223909f
C770 top:990 bot:114 0.00404523f
C771 top:990 bot:117 0.00404523f
C772 top:990 bot:120 0.00404523f
C773 top:990 bot:123 0.00404523f
C774 top:990 bot:126 0.00404523f
C775 top:990 bot:129 0.00404523f
C776 top:990 bot:132 0.00404523f
C777 top:990 bot:135 0.00404523f
C778 top:990 bot:138 0.00404523f
C779 top:990 bot:141 0.00404523f
C780 top:990 bot:144 0.00404523f
C781 top:990 bot:147 0.00404523f
C782 top:990 bot:227 0.00298962f
C783 top:990 bot:228 0.00410419f
C784 top:990 bot:229 0.00410419f
C785 top:990 bot:230 0.00410419f
C786 top:990 bot:231 0.00410419f
C787 top:990 bot:232 0.00410419f
C788 top:990 bot:233 0.00410419f
C789 top:990 bot:234 0.00410419f
C790 top:990 bot:235 0.00410419f
C791 top:990 bot:236 0.00410419f
C792 top:990 bot:237 0.00410419f
C793 top:990 bot:238 0.00410419f
C794 top:990 bot:266 0.00406601f
C795 top:990 bot:269 0.00406601f
C796 top:990 bot:272 0.00406601f
C797 top:990 bot:275 0.00406601f
C798 top:990 bot:278 0.00406601f
C799 top:990 bot:281 0.00406601f
C800 top:990 bot:284 0.00406601f
C801 top:990 bot:287 0.00406601f
C802 top:990 bot:290 0.00406601f
C803 top:990 bot:293 0.00406601f
C804 top:990 bot:296 0.00406601f
C805 top:990 bot:299 0.00406601f
C806 top:990 bot:379 0.00298962f
C807 top:990 bot:380 0.00410419f
C808 top:990 bot:381 0.00410419f
C809 top:990 bot:382 0.00410419f
C810 top:990 bot:383 0.00410419f
C811 top:990 bot:384 0.00410419f
C812 top:990 bot:385 0.00410419f
C813 top:990 bot:386 0.00410419f
C814 top:990 bot:387 0.00410419f
C815 top:990 bot:388 0.00410419f
C816 top:990 bot:389 0.00410419f
C817 top:990 bot:390 0.00410419f
C818 top:990 bot:1521 0.0109644f
C819 top:990 bot:1545 0.0118164f
C820 top:990 bot:1567 0.0117402f
C821 top:990 bot:1589 0.0116475f
C822 top:990 bot:1611 0.0115631f
C823 top:990 bot:1633 0.0114792f
C824 top:990 bot:1655 0.011418f
C825 top:990 bot:1679 0.0113266f
C826 top:990 bot:1703 0.0111965f
C827 top:990 bot:1727 0.011071f
C828 top:990 bot:1751 0.0109635f
C829 top:990 bot:1775 0.0108817f
C830 top:990 bot:1799 0.00182287f
C831 top:1247 Mpcap<1>:g 7.12928e-19
C832 top:1247 bot:1045 0.0125773f
C833 top:1247 bot:1516 4.93078e-19
C834 top:1247 bot:1521 7.65851e-19
C835 top:1247 bot:1540 0.0014297f
C836 top:1247 bot:1840 0.0127207f
C837 top:1247 bot:1850 0.0344235f
C838 top:1247 bot:1935 0.00240223f
C839 top:1259 bot:1521 2.33348e-19
C840 top:1259 bot:1545 0.00137945f
C841 top:1264 bot:1204 2.08684e-19
C842 top:1264 bot:1850 0.00277393f
C843 top:1269 Mpcap<1>:g 7.12928e-19
C844 top:1269 Mpcap<1>==2:g 7.12928e-19
C845 top:1269 bot:1045 0.0119009f
C846 top:1269 bot:1540 2.23717e-19
C847 top:1269 bot:1545 7.65851e-19
C848 top:1269 bot:1562 0.00119987f
C849 top:1269 bot:1850 0.0122271f
C850 top:1269 bot:1856 0.0328043f
C851 top:1269 bot:1935 0.00228378f
C852 top:1269 bot:1945 0.00226798f
C853 top:1281 bot:1545 2.16616e-19
C854 top:1281 bot:1567 0.00153751f
C855 top:1286 bot:1204 2.08684e-19
C856 top:1286 bot:1856 0.00283837f
C857 top:1291 Mpcap<1>==2:g 7.12928e-19
C858 top:1291 Mpcap<1>==3:g 7.12928e-19
C859 top:1291 bot:1045 0.0119944f
C860 top:1291 bot:1562 2.43216e-19
C861 top:1291 bot:1567 7.65851e-19
C862 top:1291 bot:1584 0.00101583f
C863 top:1291 bot:1856 0.0128502f
C864 top:1291 bot:1862 0.0309958f
C865 top:1291 bot:1945 0.00228292f
C866 top:1291 bot:1955 0.0022694f
C867 top:1303 bot:1567 2.06625e-19
C868 top:1303 bot:1589 0.00171968f
C869 top:1308 bot:1204 2.08684e-19
C870 top:1308 bot:1862 0.00290668f
C871 top:1313 Mpcap<1>==3:g 7.12928e-19
C872 top:1313 Mpcap<1>==4:g 7.12928e-19
C873 top:1313 bot:1045 0.0120566f
C874 top:1313 bot:1584 2.63741e-19
C875 top:1313 bot:1589 7.65851e-19
C876 top:1313 bot:1606 8.77884e-19
C877 top:1313 bot:1862 0.013511f
C878 top:1313 bot:1868 0.0293039f
C879 top:1313 bot:1955 0.00228204f
C880 top:1313 bot:1965 0.00227076f
C881 top:1325 bot:1611 0.00190274f
C882 top:1330 bot:1204 2.08684e-19
C883 top:1330 bot:1868 0.00297944f
C884 top:1335 Mpcap<1>==4:g 7.12928e-19
C885 top:1335 Mpcap<1>==5:g 7.12928e-19
C886 top:1335 bot:1045 0.0121355f
C887 top:1335 bot:1606 2.89239e-19
C888 top:1335 bot:1611 7.65851e-19
C889 top:1335 bot:1628 7.56081e-19
C890 top:1335 bot:1868 0.0142119f
C891 top:1335 bot:1874 0.0277196f
C892 top:1335 bot:1965 0.00228111f
C893 top:1335 bot:1975 0.00227206f
C894 top:1347 bot:1633 0.00212053f
C895 top:1352 bot:1204 2.08684e-19
C896 top:1352 bot:1874 0.00305728f
C897 top:1357 Mpcap<1>==5:g 7.12928e-19
C898_2 top:1357 Mpcap<1>==6:g 7.12928e-19
C899_2 top:1357 bot:1045 0.0121934f
C900_2 top:1357 bot:1628 3.18743e-19
C901_2 top:1357 bot:1633 7.65851e-19
C902_2 top:1357 bot:1650 6.56176e-19
C903_2 top:1357 bot:1874 0.0149557f
C904_2 top:1357 bot:1881 0.0262346f
C905_2 top:1357 bot:1975 0.00228016f
C906_2 top:1357 bot:1985 0.00227333f
C907_2 top:1369 bot:1655 0.00239416f
C908_2 top:1374 bot:1204 2.08684e-19
C909_2 top:1374 bot:1881 0.00314094f
C910_2 top:1379 Mpcap<1>==6:g 7.12928e-19
C911_2 top:1379 Mpcap<1>==7:g 7.12928e-19
C912_2 top:1379 bot:1045 0.0122355f
C913_2 top:1379 bot:1650 3.53117e-19
C914_2 top:1379 bot:1655 7.65851e-19
C915_2 top:1379 bot:1674 5.73651e-19
C916_2 top:1379 bot:1881 0.0157452f
C917_2 top:1379 bot:1888 0.0248416f
C918_2 top:1379 bot:1985 0.00227916f
C919_2 top:1379 bot:1995 0.00227454f
C920_2 top:1392 bot:1679 0.00273571f
C921_2 top:1397 bot:1204 2.08684e-19
C922_2 top:1397 bot:1888 0.00323108f
C923_2 top:1402 Mpcap<1>==7:g 7.12928e-19
C924_2 top:1402 Mpcap<1>==8:g 7.12928e-19
C925_2 top:1402 bot:1045 0.0122576f
C926_2 top:1402 bot:1674 3.93399e-19
C927_2 top:1402 bot:1679 7.65851e-19
C928_2 top:1402 bot:1698 5.04978e-19
C929_2 top:1402 bot:1888 0.0165836f
C930_2 top:1402 bot:1895 0.0235341f
C931_2 top:1402 bot:1995 0.00227813f
C932_2 top:1402 bot:2005 0.00227571f
C933_2 top:1415 bot:1703 0.00315222f
C934_2 top:1420 bot:1204 2.08684e-19
C935_2 top:1420 bot:1895 0.00332896f
C936_2 top:1425 Mpcap<1>==8:g 7.12928e-19
C937_2 top:1425 Mpcap<1>==9:g 7.12928e-19
C938_2 top:1425 bot:1045 0.0122598f
C939_2 top:1425 bot:1698 4.37142e-19
C940_2 top:1425 bot:1703 7.65851e-19
C941_2 top:1425 bot:1722 4.47488e-19
C942_2 top:1425 bot:1895 0.0174743f
C943_2 top:1425 bot:1902 0.0223061f
C944_2 top:1425 bot:2005 0.00227705f
C945_2 top:1425 bot:2015 0.00227683f
C946_2 top:1438 bot:1727 0.00353357f
C947_2 top:1443 bot:1204 2.08684e-19
C948_2 top:1443 bot:1902 0.00343587f
C949_2 top:1448 Mpcap<1>==9:g 7.12928e-19
C950_2 top:1448 Mpcap<1>==10:g 7.12928e-19
C951_2 top:1448 bot:1045 0.0122584f
C952_2 top:1448 bot:1722 4.92639e-19
C953_2 top:1448 bot:1727 7.65851e-19
C954_2 top:1448 bot:1746 4.02274e-19
C955_2 top:1448 bot:1902 0.0184211f
C956_2 top:1448 bot:1909 0.0211523f
C957_2 top:1448 bot:2015 0.00227594f
C958_2 top:1448 bot:2025 0.00227792f
C959_2 top:1461 bot:1751 0.00399759f
C960_2 top:1466 bot:1204 2.08684e-19
C961_2 top:1466 bot:1909 0.00355341f
C962_2 top:1471 Mpcap<1>==10:g 7.12928e-19
C963_2 top:1471 Mpcap<1>==11:g 7.12928e-19
C964_2 top:1471 bot:1045 0.012242f
C965_2 top:1471 bot:1746 5.5891e-19
C966_2 top:1471 bot:1751 7.65851e-19
C967_2 top:1471 bot:1770 3.60663e-19
C968_2 top:1471 bot:1909 0.019428f
C969_2 top:1471 bot:1916 0.0200677f
C970_2 top:1471 bot:2025 0.00227478f
C971_2 top:1471 bot:2035 0.00227896f
C972_2 top:1484 bot:1775 0.00461866f
C973_2 top:1489 bot:1204 2.08684e-19
C974_2 top:1489 bot:1916 0.00368339f
C975_2 top:1494 Mpcap<1>==11:g 7.12928e-19
C976_2 top:1494 Mpcap<1>==12:g 7.12928e-19
C977_2 top:1494 bot:1045 0.0122031f
C978_2 top:1494 bot:1770 6.38405e-19
C979_2 top:1494 bot:1775 7.65851e-19
C980_2 top:1494 bot:1794 3.25198e-19
C981_2 top:1494 bot:1916 0.0204996f
C982_2 top:1494 bot:1923 0.0190478f
C983_2 top:1494 bot:2035 0.00227357f
C984_2 top:1494 bot:2045 0.00227996f
C985_2 top:1507 bot:1799 0.00525763f
C986_2 top:1512 bot:1204 2.08684e-19
C987_2 top:1512 bot:1923 0.00382805f
C988_2 top:1517 Mpcap<1>==12:g 7.12928e-19
C989_2 top:1517 bot:1045 0.00251524f
C990_2 top:1517 bot:1794 0.00130979f
C991_2 top:1517 bot:1799 7.65851e-19
C992_2 top:1517 bot:1923 0.0208244f
C993_2 top:1517 bot:2045 0.00235384f
C994_2 top:1539 bot:1204 0.0206548f
C995_2 top:1539 bot:1521 0.0111307f
C996_2 top:1539 bot:1535 0.00278104f
C997_2 top:1539 bot:1545 0.0324393f
C998_2 top:1539 bot:1850 0.0435154f
C999_2 top:1539 bot:1856 0.0158982f
C1000_2 top:1545 bot:1204 0.0203143f
C1001_2 top:1545 bot:1545 0.0111226f
C1002_2 top:1545 bot:1557 0.00278747f
C1003_2 top:1545 bot:1567 0.0335355f
C1004_2 top:1545 bot:1856 0.0450853f
C1005_2 top:1545 bot:1862 0.0156494f
C1006_2 top:1551 bot:1204 0.0199581f
C1007_2 top:1551 bot:1567 0.0107933f
C1008_2 top:1551 bot:1579 0.00279505f
C1009_2 top:1551 bot:1589 0.0346745f
C1010_2 top:1551 bot:1862 0.046761f
C1011_2 top:1551 bot:1868 0.0153964f
C1012_2 top:1557 bot:1204 0.0195778f
C1013_2 top:1557 bot:1589 0.0104752f
C1014_2 top:1557 bot:1601 0.00280412f
C1015_2 top:1557 bot:1611 0.0358589f
C1016_2 top:1557 bot:1868 0.0483464f
C1017_2 top:1557 bot:1874 0.0151403f
C1018_2 top:1563 bot:1204 0.0191752f
C1019_2 top:1563 bot:1611 0.0101679f
C1020_2 top:1563 bot:1623 0.00281504f
C1021_2 top:1563 bot:1633 0.0370913f
C1022_2 top:1563 bot:1874 0.0498188f
C1023_2 top:1563 bot:1881 0.0148842f
C1024_2 top:1570 bot:1204 0.0187599f
C1025_2 top:1570 bot:1633 0.00987103f
C1026_2 top:1570 bot:1645 0.0028282f
C1027_2 top:1570 bot:1655 0.0383747f
C1028_2 top:1570 bot:1881 0.0514113f
C1029_2 top:1570 bot:1888 0.014631f
C1030_2 top:1577 bot:1204 0.0183334f
C1031_2 top:1577 bot:1655 0.0095842f
C1032_2 top:1577 bot:1669 0.00284391f
C1033_2 top:1577 bot:1679 0.0397127f
C1034_2 top:1577 bot:1888 0.053185f
C1035_2 top:1577 bot:1895 0.0143834f
C1036_2 top:1584 bot:1204 0.0179117f
C1037_2 top:1584 bot:1679 0.00930706f
C1038_2 top:1584 bot:1693 0.00286296f
C1039_2 top:1584 bot:1703 0.0411091f
C1040_2 top:1584 bot:1895 0.0554751f
C1041_2 top:1584 bot:1902 0.0141622f
C1042_2 top:1591 bot:1204 0.0175024f
C1043_2 top:1591 bot:1703 0.00903927f
C1044_2 top:1591 bot:1717 0.00288612f
C1045_2 top:1591 bot:1727 0.0425677f
C1046_2 top:1591 bot:1902 0.0584308f
C1047_2 top:1591 bot:1909 0.0139828f
C1048_2 top:1598 bot:1204 0.0170592f
C1049_2 top:1598 bot:1727 0.00878049f
C1050_2 top:1598 bot:1741 0.00291432f
C1051_2 top:1598 bot:1751 0.0440893f
C1052_2 top:1598 bot:1909 0.0619102f
C1053_2 top:1598 bot:1916 0.0137545f
C1054_2 top:1605 bot:1204 0.0165965f
C1055_2 top:1605 bot:1751 0.00853042f
C1056_2 top:1605 bot:1765 0.00294881f
C1057_2 top:1605 bot:1775 0.0456822f
C1058_2 top:1605 bot:1916 0.0650991f
C1059_2 top:1605 bot:1923 0.0135257f
C1060_2 top:1612 bot:1204 0.013144f
C1061_2 top:1612 bot:1775 0.00828873f
C1062_2 top:1612 bot:1789 0.00299096f
C1063_2 top:1612 bot:1799 0.0326508f
C1064_2 top:1612 bot:1923 0.068877f
C1065_2 top:1622 bot:1521 0.00241932f
C1066_2 top:1622 bot:1545 0.00226682f
C1067_2 top:1628 bot:1545 0.00228411f
C1068_2 top:1628 bot:1567 0.00226592f
C1069_2 top:1634 bot:1567 0.0022846f
C1070_2 top:1634 bot:1589 0.002265f
C1071_2 top:1640 bot:1589 0.00228508f
C1072_2 top:1640 bot:1611 0.00226406f
C1073_2 top:1646 bot:1611 0.00228555f
C1074_2 top:1646 bot:1633 0.00226312f
C1075_2 top:1652 bot:1633 0.00228601f
C1076_2 top:1652 bot:1655 0.00226216f
C1077_2 top:1658 bot:1655 0.00228645f
C1078_2 top:1658 bot:1679 0.00226119f
C1079_2 top:1664 bot:1679 0.00228689f
C1080_2 top:1664 bot:1703 0.0022602f
C1081_2 top:1670 bot:1703 0.00228732f
C1082_2 top:1670 bot:1727 0.00225919f
C1083_2 top:1676 bot:1727 0.00228773f
C1084_2 top:1676 bot:1751 0.00225838f
C1085_2 top:1682 bot:1751 0.00228814f
C1086_2 top:1682 bot:1775 0.00225758f
C1087_2 top:1688 bot:1775 0.00228854f
C1088_2 top:1688 bot:1799 0.00233834f
C1089_2 top:1775 Mpcap<1>:g 0.0158744f
C1090_2 top:1775 Mpcap<1>==2:g 0.0158744f
C1091_2 top:1775 Mpcap<1>==3:g 0.0158744f
C1092_2 top:1775 Mpcap<1>==4:g 0.0158744f
C1093_2 top:1775 Mpcap<1>==5:g 0.0158744f
C1094_2 top:1775 Mpcap<1>==6:g 0.0158744f
C1095_2 top:1775 Mpcap<1>==7:g 0.0158744f
C1096 top:1775 Mpcap<1>==8:g 0.0158744f
C1097 top:1775 Mpcap<1>==9:g 0.0158744f
C1098 top:1775 Mpcap<1>==10:g 0.0158744f
C1099 top:1775 Mpcap<1>==11:g 0.0158744f
C1100 top:1775 Mpcap<1>==12:g 0.0158744f
C1101 top:1807 bot:1840 8.79217e-19
C1102 top:872 in 0.00521362f
C1103 top:872 in:27 0.0016778f
C1104 top:990 in 2.49426e-19
C718_2 top:1807 0 0.0132631f
C719_2 top:1781 0 7.59902e-21
C720_2 top:1777 0 0.0132707f
C721_2 top:1775 0 0.00229922f
C722_2 top:1688 0 0.044561f
C723_2 top:1682 0 0.0369102f
C724_2 top:1676 0 0.0369102f
C725_2 top:1670 0 0.0369102f
C726_2 top:1664 0 0.0369102f
C727_2 top:1658 0 0.0369102f
C728_2 top:1652 0 0.0369102f
C729_2 top:1646 0 0.0369102f
C730_2 top:1640 0 0.0369102f
C731_2 top:1634 0 0.0369102f
C732_2 top:1628 0 0.0369102f
C733_2 top:1622 0 0.0443783f
C734_2 top:1612 0 0.051052f
C735_2 top:1605 0 0.0339785f
C736_2 top:1598 0 0.0334033f
C737_2 top:1591 0 0.033379f
C738_2 top:1584 0 0.0333469f
C739_2 top:1577 0 0.0333304f
C740_2 top:1570 0 0.0333249f
C741_2 top:1563 0 0.0333221f
C742_2 top:1557 0 0.0333214f
C743_2 top:1551 0 0.0333184f
C744_2 top:1545 0 0.0333127f
C745_2 top:1539 0 0.0326544f
C746_2 top:1517 0 0.0319099f
C747_2 top:1512 0 3.98256e-19
C748_2 top:1507 0 2.10599e-19
C749_2 top:1494 0 0.0162512f
C750_2 top:1489 0 3.98256e-19
C751_2 top:1484 0 2.14916e-19
C752_2 top:1471 0 0.0159543f
C753_2 top:1466 0 3.98256e-19
C754_2 top:1461 0 2.20231e-19
C755_2 top:1448 0 0.0159649f
C756_2 top:1443 0 3.98256e-19
C757_2 top:1438 0 2.26362e-19
C758_2 top:1425 0 0.0159679f
C759_2 top:1420 0 3.98256e-19
C760_2 top:1415 0 2.32897e-19
C761_2 top:1402 0 0.0159634f
C762_2 top:1397 0 3.98256e-19
C763_2 top:1392 0 2.39143e-19
C764_2 top:1379 0 0.0159512f
C765_2 top:1374 0 3.98256e-19
C766_2 top:1369 0 2.45647e-19
C767_2 top:1357 0 0.0159308f
C768_2 top:1352 0 3.98256e-19
C769_2 top:1347 0 2.53646e-19
C770_2 top:1335 0 0.0159015f
C771_2 top:1330 0 3.98256e-19
C772_2 top:1325 0 2.62221e-19
C773_2 top:1313 0 0.0158622f
C774_2 top:1308 0 3.98256e-19
C775_2 top:1303 0 6.49027e-20
C776_2 top:1291 0 0.0158116f
C777_2 top:1286 0 3.98256e-19
C778_2 top:1281 0 6.49027e-20
C779_2 top:1269 0 0.0157478f
C780_2 top:1264 0 3.98256e-19
C781_2 top:1259 0 6.49027e-20
C782_2 top:1247 0 0.0182671f
C783_2 top:990 0 0.0551881f
C784_2 top:872 0 0.0682243f
C785_2 top:866 0 0.159869f
C786_2 top:742 0 0.00435565f
C787_2 top:738 0 0.0230117f
C788_2 top:736 0 0.0211208f
C789_2 top:731 0 0.00566297f
C790_2 top:726 0 0.00734521f
C791_2 top:721 0 0.00577165f
C792_2 top:716 0 0.0214296f
C793_2 top:364 0 0.0207775f
C794_2 top:363 0 0.0173713f
C795_2 top:362 0 0.0173713f
C796_2 top:361 0 0.0173713f
C797_2 top:360 0 0.0173713f
C798_2 top:359 0 0.0173713f
C799_2 top:358 0 0.0173713f
C800_2 top:357 0 0.0173713f
C801_2 top:356 0 0.0173713f
C802_2 top:355 0 0.0173713f
C803_2 top:354 0 0.0173713f
C804_2 top:353 0 0.0208203f
C805_2 top:316 0 0.0480953f
C806_2 top:315 0 0.0377875f
C807_2 top:314 0 0.0377875f
C808_2 top:313 0 0.0377875f
C809_2 top:312 0 0.0377875f
C810_2 top:311 0 0.0377875f
C811_2 top:310 0 0.0377875f
C812_2 top:309 0 0.0377875f
C813_2 top:308 0 0.0377875f
C814_2 top:307 0 0.0377875f
C815_2 top:306 0 0.0377875f
C816_2 top:305 0 0.0480953f
C817_2 top:292 0 2.22518e-20
C818_2 top:291 0 2.22518e-20
C819_2 top:290 0 2.22518e-20
C820_2 top:289 0 2.22518e-20
C821_2 top:288 0 2.22518e-20
C822_2 top:287 0 2.22518e-20
C823_2 top:286 0 2.22518e-20
C824_2 top:285 0 2.22518e-20
C825_2 top:284 0 2.22518e-20
C826_2 top:283 0 2.22518e-20
C827_2 top:282 0 2.22518e-20
C828_2 top:281 0 0.0614709f
C829_2 top:279 0 0.0614709f
C830_2 top:204 0 0.0348533f
C831_2 top:201 0 4.33203e-21
C832_2 top:198 0 4.33203e-21
C833_2 top:195 0 4.33203e-21
C834_2 top:192 0 4.33203e-21
C835_2 top:189 0 4.33203e-21
C836_2 top:186 0 4.33203e-21
C837_2 top:183 0 4.33203e-21
C838_2 top:180 0 4.33203e-21
C839_2 top:177 0 4.33203e-21
C840_2 top:174 0 4.33203e-21
C841_2 top:171 0 4.33203e-21
C842_2 top:168 0 0.0480043f
C843_2 top:140 0 1.46528e-20
C844_2 top:139 0 1.46528e-20
C845_2 top:138 0 1.46528e-20
C846_2 top:137 0 1.46528e-20
C847_2 top:136 0 1.46528e-20
C848_2 top:135 0 1.46528e-20
C849_2 top:134 0 1.46528e-20
C850_2 top:133 0 1.46528e-20
C851_2 top:132 0 1.46528e-20
C852_2 top:131 0 1.46528e-20
C853_2 top:130 0 1.46528e-20
C854_2 top:129 0 0.0614553f
C855_2 top:127 0 0.0614633f
C856_2 top:52 0 0.034849f
C857_2 top:16 0 0.0352866f
R858_2 top:1804 top:1807 1.1875
R859_2 top:1786 top:1789 1.1875
R860_2 top:1784 top:1804 3.325
R861_2 top:1783 top:1800 4.5125
R862_2 top:1782 top:1800 4.5125
R863_2 top:1781 top:1796 4.5125
R864_2 top:1780 top:1796 4.5125
R865_2 top:1779 top:1792 4.5125
R866_2 top:1778 top:1792 4.5125
R867_2 top:1777 top:1789 3.325
R868_2 top:1773 top:1775 9.35
R869_2 top:1771 top:1773 14.025
R870_2 top:1769 top:1771 14.025
R871_2 top:1767 top:1769 14.025
R872_2 top:1765 top:1767 14.025
R873_2 top:1763 top:1765 14.025
R874_2 top:1761 top:1763 14.025
R875_2 top:1759 top:1761 14.025
R876_2 top:1757 top:1759 14.025
R877_2 top:1755 top:1757 14.025
R878_2 top:1753 top:1755 14.025
R879_2 top:1751 top:1753 14.025
R880_2 top:1749 top:1751 14.025
R881_2 top:1747 top:1749 14.025
R882_2 top:1745 top:1747 14.025
R883_2 top:1743 top:1745 14.025
R884_2 top:1741 top:1743 14.025
R885_2 top:1739 top:1741 14.025
R886_2 top:1737 top:1739 14.025
R887_2 top:1730 top:1732 14.025
R888_2 top:1728 top:1730 14.025
R889_2 top:1726 top:1728 14.025
R890_2 top:1724 top:1726 14.025
R891_2 top:1722 top:1724 14.025
R892_2 top:1720 top:1722 14.025
R893_2 top:1718 top:1720 14.025
R894_2 top:1716 top:1718 14.025
R895_2 top:1714 top:1716 14.025
R896_2 top:1712 top:1714 14.025
R897_2 top:1710 top:1712 14.025
R898_2 top:1708 top:1710 14.025
R899_2 top:1706 top:1708 14.025
R900_2 top:1704 top:1706 14.586
R901_2 top:1702 top:1704 14.586
R902_2 top:1700 top:1702 14.586
R903_2 top:1698 top:1700 14.586
R904_2 top:1696 top:1698 14.586
R905_2 top:1693 top:1696 14.586
R906_2 top:1615 top:1616 3.89188
R907_2 top:1612 top:1616 3.75004
R908_2 top:1608 top:1609 3.87697
R909_2 top:1605 top:1609 3.75004
R910_2 top:1601 top:1602 3.87915
R911_2 top:1598 top:1602 3.75004
R912_2 top:1594 top:1595 3.90986
R913_2 top:1591 top:1595 3.75004
R914_2 top:1587 top:1588 3.93235
R915_2 top:1584 top:1588 3.75004
R916_2 top:1580 top:1581 3.93235
R917_2 top:1577 top:1581 3.75004
R918_2 top:1573 top:1574 3.91215
R919_2 top:1570 top:1574 3.75004
R920_2 top:1566 top:1567 3.8882
R921_2 top:1563 top:1567 3.75004
R922_2 top:1557 top:1560 7.5973
R923_2 top:1551 top:1554 7.5973
R924_2 top:1545 top:1548 7.5973
R925_2 top:1539 top:1542 7.5973
R926_2 top:1525 top:1527 1.39739
R927_2 top:1523 top:1525 2.89459
R928_2 top:1520 top:1523 1.39739
R929_2 top:1520 top:1521 2.36225
R930_2 top:1517 top:1521 1.1804
R931_2 top:1512 top:1615 2.25
R932_2 top:1507 top:1612 8
R933_2 top:1502 top:1504 1.39739
R934_2 top:1500 top:1502 2.89459
R935_2 top:1497 top:1500 1.39739
R936_2 top:1497 top:1498 2.36225
R937_2 top:1494 top:1498 1.16595
R938_2 top:1489 top:1608 2.25
R939_2 top:1484 top:1605 8
R940_2 top:1479 top:1481 1.39739
R941 top:1477 top:1479 2.89459
R942 top:1474 top:1477 1.39739
R943 top:1474 top:1475 2.36225
R944 top:1471 top:1475 1.16569
R945 top:1466 top:1601 2.25
R946 top:1461 top:1598 8
R947 top:1456 top:1458 1.39739
R948 top:1454 top:1456 2.89459
R949 top:1451 top:1454 1.39739
R950 top:1451 top:1452 2.36225
R951 top:1448 top:1452 1.17554
R952 top:1443 top:1594 2.25
R953 top:1438 top:1591 8
R954 top:1433 top:1435 1.39739
R955 top:1431 top:1433 2.89459
R956 top:1428 top:1431 1.39739
R957 top:1428 top:1429 2.36225
R958 top:1425 top:1429 1.16818
R959 top:1420 top:1587 2.25
R960 top:1415 top:1584 8
R961 top:1410 top:1412 1.39739
R962 top:1408 top:1410 2.89459
R963 top:1405 top:1408 1.39739
R964 top:1405 top:1406 2.36225
R965 top:1402 top:1406 1.16212
R966 top:1397 top:1580 2.25
R967 top:1392 top:1577 8
R968 top:1387 top:1389 1.39739
R969 top:1385 top:1387 2.89459
R970 top:1382 top:1385 1.39739
R971 top:1382 top:1383 2.36225
R972 top:1379 top:1383 1.16622
R973 top:1374 top:1573 2.25
R974 top:1369 top:1570 8
R975 top:1364 top:1366 1.39739
R976 top:1362 top:1364 2.89459
R977 top:1360 top:1362 1.39739
R978 top:1357 top:1360 3.54338
R979 top:1352 top:1566 2.25
R980 top:1347 top:1563 8
R981 top:1342 top:1344 1.39739
R982 top:1340 top:1342 2.89459
R983 top:1338 top:1340 1.39739
R984 top:1335 top:1338 3.54338
R985 top:1330 top:1560 2.25
R986 top:1325 top:1557 8
R987 top:1320 top:1322 1.39739
R988 top:1318 top:1320 2.89459
R989 top:1316 top:1318 1.39739
R990 top:1313 top:1316 3.54338
R991 top:1308 top:1554 2.25
R992 top:1303 top:1551 8
R993 top:1298 top:1300 1.39739
R994 top:1296 top:1298 2.89459
R995 top:1294 top:1296 1.39739
R996 top:1291 top:1294 3.54338
R997 top:1286 top:1548 2.25
R998 top:1281 top:1545 8
R999 top:1276 top:1278 1.39739
R1000 top:1274 top:1276 2.89459
R1001 top:1272 top:1274 1.39739
R1002 top:1269 top:1272 3.54338
R1003 top:1264 top:1542 2.25
R1004 top:1259 top:1539 8
R1005 top:1254 top:1256 1.39739
R1006 top:1252 top:1254 2.89459
R1007 top:1250 top:1252 1.39739
R1008 top:1247 top:1250 3.54338
R1009 top:1234 top:1235 0.169621
R1010 top:1233 top:1696 26.6667
R1011 top:1233 top:1234 0.0326194
R1012 top:1231 top:1233 0.137001
R1013 top:1230 top:1693 26.6667
R1014 top:1230 top:1231 0.11743
R1015 top:1228 top:1230 0.052191
R1016 top:1226 top:1228 0.169621
R1017 top:1223 top:1527 4.5
R1018 top:1220 top:1525 1.5
R1019 top:1214 top:1523 4.5
R1020 top:1211 top:1520 1.5
R1021 top:1205 top:1504 4.5
R1022 top:1202 top:1502 1.5
R1023 top:1196 top:1500 4.5
R1024 top:1193 top:1497 1.5
R1025 top:1187 top:1481 4.5
R1026 top:1184 top:1479 1.5
R1027 top:1178 top:1477 4.5
R1028 top:1175 top:1474 1.5
R1029 top:1169 top:1458 4.5
R1030 top:1166 top:1456 1.5
R1031 top:1160 top:1454 4.5
R1032 top:1157 top:1451 1.5
R1033 top:1151 top:1435 4.5
R1034 top:1148 top:1433 1.5
R1035 top:1142 top:1431 4.5
R1036 top:1139 top:1428 1.5
R1037 top:1133 top:1412 4.5
R1038 top:1130 top:1410 1.5
R1039 top:1124 top:1408 4.5
R1040 top:1121 top:1405 1.5
R1041 top:1115 top:1389 4.5
R1042 top:1112 top:1387 1.5
R1043 top:1106 top:1385 4.5
R1044 top:1103 top:1382 1.5
R1045 top:1097 top:1366 4.5
R1046 top:1094 top:1364 1.5
R1047 top:1088 top:1362 4.5
R1048 top:1085 top:1360 1.5
R1049 top:1079 top:1344 4.5
R1050 top:1076 top:1342 1.5
R1051 top:1070 top:1340 4.5
R1052 top:1067 top:1338 1.5
R1053 top:1061 top:1322 4.5
R1054 top:1058 top:1320 1.5
R1055 top:1052 top:1318 4.5
R1056 top:1049 top:1316 1.5
R1057 top:1043 top:1300 4.5
R1058 top:1040 top:1298 1.5
R1059 top:1034 top:1296 4.5
R1060 top:1031 top:1294 1.5
R1061 top:1025 top:1278 4.5
R1062 top:1022 top:1276 1.5
R1063 top:1016 top:1274 4.5
R1064 top:1013 top:1272 1.5
R1065 top:1007 top:1256 4.5
R1066 top:1004 top:1254 1.5
R1067 top:998 top:1252 4.5
R1068 top:995 top:1250 1.5
R1069 top:990 top:1688 33.3333
R1070 top:988 top:1507 8
R1071 top:988 top:990 0.024253
R1072 top:986 top:1688 33.3333
R1073 top:986 top:988 0.848855
R1074 top:983 top:984 0.154385
R1075 top:982 top:1688 33.3333
R1076 top:982 top:986 0.873108
R1077 top:982 top:984 0.424427
R1078 top:980 top:1682 33.3333
R1079 top:980 top:983 0.424427
R1080 top:978 top:1484 8
R1081 top:978 top:980 0.0606325
R1082 top:976 top:1682 33.3333
R1083 top:976 top:978 0.812475
R1084 top:973 top:974 0.154385
R1085 top:972 top:1682 33.3333
R1086 top:972 top:976 0.873108
R1087 top:972 top:974 0.424427
R1088 top:970 top:1676 33.3333
R1089 top:970 top:973 0.424427
R1090 top:968 top:1461 8
R1091 top:968 top:970 0.097012
R1092 top:966 top:1676 33.3333
R1093 top:966 top:968 0.776096
R1094 top:963 top:964 0.154385
R1095 top:962 top:1676 33.3333
R1096_2 top:962 top:966 0.873108
R1097_2 top:962 top:964 0.424427
R1098_2 top:960 top:1670 33.3333
R1099_2 top:960 top:963 0.424427
R1100_2 top:958 top:1438 8
R1101_2 top:958 top:960 0.133391
R1102_2 top:956 top:1670 33.3333
R1103_2 top:956 top:958 0.739716
R1104_2 top:953 top:954 0.154385
R1105_2 top:952 top:1670 33.3333
R1106_2 top:952 top:956 0.873108
R1107_2 top:952 top:954 0.424427
R1108_2 top:950 top:1664 33.3333
R1109_2 top:950 top:953 0.424427
R1110_2 top:948 top:1415 8
R1111_2 top:948 top:950 0.169771
R1112_2 top:946 top:1664 33.3333
R1113_2 top:946 top:948 0.703337
R1114_2 top:943 top:944 0.154385
R1115_2 top:942 top:1664 33.3333
R1116_2 top:942 top:946 0.873108
R1117_2 top:942 top:944 0.424427
R1118_2 top:940 top:1658 33.3333
R1119_2 top:940 top:943 0.424427
R1120_2 top:938 top:1392 8
R1121_2 top:938 top:940 0.20615
R1122_2 top:936 top:1658 33.3333
R1123_2 top:936 top:938 0.666957
R1124_2 top:933 top:934 0.154385
R1125_2 top:932 top:1658 33.3333
R1126_2 top:932 top:936 0.873108
R1127_2 top:932 top:934 0.424427
R1128_2 top:930 top:1652 33.3333
R1129_2 top:930 top:933 0.424427
R1130_2 top:928 top:1369 8
R1131_2 top:928 top:930 0.24253
R1132_2 top:926 top:1652 33.3333
R1133_2 top:926 top:928 0.630578
R1134_2 top:923 top:924 0.154385
R1135_2 top:922 top:1652 33.3333
R1136_2 top:922 top:926 0.873108
R1137_2 top:922 top:924 0.424427
R1138_2 top:920 top:1646 33.3333
R1139_2 top:920 top:923 0.424427
R1140_2 top:918 top:1347 8
R1141_2 top:918 top:920 0.278909
R1142_2 top:916 top:1646 33.3333
R1143_2 top:916 top:918 0.594198
R1144_2 top:913 top:914 0.154385
R1145_2 top:912 top:1646 33.3333
R1146_2 top:912 top:916 0.873108
R1147_2 top:912 top:914 0.424427
R1148_2 top:910 top:1640 33.3333
R1149_2 top:910 top:913 0.424427
R1150_2 top:908 top:1325 8
R1151_2 top:908 top:910 0.315289
R1152_2 top:906 top:1640 33.3333
R1153_2 top:906 top:908 0.557819
R1154_2 top:903 top:904 0.154385
R1155_2 top:902 top:1640 33.3333
R1156_2 top:902 top:906 0.873108
R1157_2 top:902 top:904 0.424427
R1158_2 top:900 top:1634 33.3333
R1159_2 top:900 top:903 0.424427
R1160_2 top:898 top:1303 8
R1161_2 top:898 top:900 0.351668
R1162_2 top:896 top:1634 33.3333
R1163_2 top:896 top:898 0.521439
R1164_2 top:893 top:894 0.154385
R1165_2 top:892 top:1634 33.3333
R1166_2 top:892 top:896 0.873108
R1167_2 top:892 top:894 0.424427
R1168_2 top:890 top:1628 33.3333
R1169_2 top:890 top:893 0.424427
R1170_2 top:888 top:1281 8
R1171_2 top:888 top:890 0.388048
R1172_2 top:886 top:1628 33.3333
R1173_2 top:886 top:888 0.48506
R1174_2 top:883 top:884 0.154385
R1175_2 top:882 top:1628 33.3333
R1176_2 top:882 top:886 0.873108
R1177_2 top:882 top:884 0.424427
R1178_2 top:880 top:1622 33.3333
R1179_2 top:880 top:883 0.424427
R1180_2 top:878 top:1259 8
R1181_2 top:878 top:880 0.424427
R1182_2 top:876 top:1622 33.3333
R1183_2 top:876 top:878 0.44868
R1184_2 top:872 top:1622 33.3333
R1185_2 top:872 top:876 0.873108
R1186_2 top:866 top:1517 2.25
R1187_2 top:864 top:1775 80
R1188_2 top:864 top:866 0.130477
R1189_2 top:862 top:1512 2.25
R1190_2 top:862 top:864 0.00652387
R1191_2 top:860 top:1773 26.6667
R1192_2 top:860 top:862 0.156573
R1193_2 top:858 top:1771 26.6667
R1194_2 top:858 top:860 0.244645
R1195_2 top:856 top:1494 2.25
R1196_2 top:856 top:858 0.192454
R1197_2 top:854 top:1769 26.6667
R1198_2 top:854 top:856 0.052191
R1199_2 top:852 top:1489 2.25
R1200_2 top:852 top:854 0.0945962
R1201_2 top:850 top:1767 26.6667
R1202_2 top:850 top:852 0.150049
R1203_2 top:848 top:1765 26.6667
R1204_2 top:848 top:850 0.244645
R1205_2 top:846 top:1471 2.25
R1206_2 top:846 top:848 0.189192
R1207_2 top:844 top:1763 26.6667
R1208_2 top:844 top:846 0.0554529
R1209_2 top:842 top:1466 2.25
R1210_2 top:842 top:844 0.10112
R1211_2 top:840 top:1761 26.6667
R1212_2 top:840 top:842 0.143525
R1213_2 top:838 top:1759 26.6667
R1214_2 top:838 top:840 0.244645
R1215_2 top:836 top:1448 2.25
R1216_2 top:836 top:838 0.18593
R1217_2 top:834 top:1757 26.6667
R1218_2 top:834 top:836 0.0587149
R1219_2 top:832 top:1443 2.25
R1220_2 top:832 top:834 0.107644
R1221_2 top:830 top:1755 26.6667
R1222_2 top:830 top:832 0.137001
R1223_2 top:828 top:1753 26.6667
R1224_2 top:828 top:830 0.244645
R1225_2 top:826 top:1425 2.25
R1226_2 top:826 top:828 0.182668
R1227_2 top:824 top:1751 26.6667
R1228_2 top:824 top:826 0.0619768
R1229_2 top:822 top:1420 2.25
R1230_2 top:822 top:824 0.114168
R1231_2 top:820 top:1749 26.6667
R1232_2 top:820 top:822 0.130477
R1233_2 top:818 top:1747 26.6667
R1234_2 top:818 top:820 0.244645
R1235_2 top:816 top:1402 2.25
R1236_2 top:816 top:818 0.179407
R1237_2 top:814 top:1745 26.6667
R1238_2 top:814 top:816 0.0652387
R1239_2 top:812 top:1397 2.25
R1240_2 top:812 top:814 0.120692
R1241_2 top:810 top:1743 26.6667
R1242_2 top:810 top:812 0.123954
R1243_2 top:808 top:1741 26.6667
R1244_2 top:808 top:810 0.244645
R1245_2 top:806 top:1379 2.25
R1246_2 top:806 top:808 0.176145
R1247_2 top:804 top:1739 26.6667
R1248_2 top:804 top:806 0.0685007
R1249_2 top:802 top:1374 2.25
R1250_2 top:802 top:804 0.127216
R1251_2 top:800 top:1737 26.6667
R1252_2 top:800 top:802 0.11743
R1253_2 top:798 top:1732 26.6667
R1254_2 top:798 top:800 0.244645
R1255_2 top:796 top:1357 2.25
R1256_2 top:796 top:798 0.172883
R1257_2 top:794 top:1730 26.6667
R1258_2 top:794 top:796 0.0717626
R1259_2 top:792 top:1352 2.25
R1260_2 top:792 top:794 0.133739
R1261_2 top:790 top:1728 26.6667
R1262_2 top:790 top:792 0.110906
R1263_2 top:788 top:1726 26.6667
R1264_2 top:788 top:790 0.244645
R1265_2 top:786 top:1335 2.25
R1266_2 top:786 top:788 0.169621
R1267_2 top:784 top:1724 26.6667
R1268_2 top:784 top:786 0.0750246
R1269_2 top:782 top:1330 2.25
R1270_2 top:782 top:784 0.140263
R1271_2 top:780 top:1722 26.6667
R1272_2 top:780 top:782 0.104382
R1273_2 top:778 top:1720 26.6667
R1274_2 top:778 top:780 0.244645
R1275_2 top:776 top:1313 2.25
R1276_2 top:776 top:778 0.166359
R1277_2 top:774 top:1718 26.6667
R1278_2 top:774 top:776 0.0782865
R1279_2 top:772 top:1308 2.25
R1280_2 top:772 top:774 0.146787
R1281_2 top:770 top:1716 26.6667
R1282_2 top:770 top:772 0.0978581
R1283_2 top:768 top:1714 26.6667
R1284_2 top:768 top:770 0.244645
R1285_2 top:766 top:1291 2.25
R1286_2 top:766 top:768 0.163097
R1287_2 top:764 top:1712 26.6667
R1288_2 top:764 top:766 0.0815484
R1289_2 top:762 top:1286 2.25
R1290_2 top:762 top:764 0.153311
R1291_2 top:760 top:1710 26.6667
R1292_2 top:760 top:762 0.0913342
R1293_2 top:758 top:1708 26.6667
R1294_2 top:758 top:760 0.244645
R1295_2 top:756 top:1269 2.25
R1296_2 top:756 top:758 0.159835
R1297_2 top:754 top:1706 26.6667
R1298_2 top:754 top:756 0.0848104
R1299_2 top:752 top:1264 2.25
R1300_2 top:752 top:754 0.159835
R1301_2 top:750 top:1704 26.6667
R1302_2 top:750 top:752 0.0945962
R1303_2 top:748 top:1702 26.6667
R1304_2 top:748 top:750 0.254431
R1305_2 top:746 top:1247 2.25
R1306_2 top:746 top:748 0.137001
R1307_2 top:744 top:1700 26.6667
R1308_2 top:744 top:746 0.11743
R1309_2 top:742 top:744 0.169621
R1310_2 top:740 top:1698 26.6667
R1311_2 top:740 top:742 0.0848104
R1312_2 top:738 top:1235 0.0163097
R1313_2 top:738 top:740 0.0358813
R1314_2 top:735 top:1807 45
R1315_2 top:735 top:736 0.267534
R1316_2 top:733 top:1235 0.52908
R1317_2 top:733 top:736 1.1199
R1318_2 top:730 top:1800 45
R1319_2 top:730 top:731 0.497966
R1320_2 top:728 top:1234 0.52908
R1321_2 top:728 top:731 1.13045
R1322_2 top:725 top:1796 45
R1323_2 top:725 top:726 0.497966
R1324_2 top:723 top:1231 0.52908
R1325_2 top:723 top:726 1.13045
R1326_2 top:720 top:1792 45
R1327_2 top:720 top:721 0.497966
R1328_2 top:718 top:1228 0.52908
R1329_2 top:718 top:721 1.13045
R1330_2 top:715 top:1786 45
R1331_2 top:715 top:716 0.267534
R1332_2 top:713 top:1226 0.52908
R1333_2 top:713 top:716 1.1199
R1334_2 top:398 top:1688 8.47244
R1335_2 top:395 top:1682 8.47244
R1336_2 top:392 top:1676 8.47244
R1337_2 top:389 top:1670 8.47244
R1338_2 top:386 top:1664 8.47244
R1339_2 top:383 top:1658 8.47244
R1340_2 top:380 top:1652 8.47244
R1341_2 top:377 top:1646 8.47244
R1342_2 top:374 top:1640 8.47244
R1343_2 top:371 top:1634 8.47244
R1344_2 top:368 top:1628 8.47244
R1345_2 top:365 top:1622 8.47244
R1346_2 top:364 top:398 29.2153
R1347_2 top:363 top:395 29.2153
R1348_2 top:362 top:392 29.2153
R1349_2 top:361 top:389 29.2153
R1350_2 top:360 top:386 29.2153
R1351_2 top:359 top:383 29.2153
R1352_2 top:358 top:380 29.2153
R1353_2 top:357 top:377 29.2153
R1354_2 top:356 top:374 29.2153
R1355_2 top:355 top:371 29.2153
R1356_2 top:354 top:368 29.2153
R1357_2 top:353 top:365 29.2153
R1358_2 top:351 top:1688 8.47244
R1359_2 top:348 top:1682 8.47244
R1360_2 top:345 top:1676 8.47244
R1361_2 top:342 top:1670 8.47244
R1362_2 top:339 top:1664 8.47244
R1363_2 top:336 top:1658 8.47244
R1364_2 top:333 top:1652 8.47244
R1365_2 top:330 top:1646 8.47244
R1366_2 top:327 top:1640 8.47244
R1367_2 top:324 top:1634 8.47244
R1368_2 top:321 top:1628 8.47244
R1369_2 top:318 top:1622 8.47244
R1370_2 top:316 top:351 29.2153
R1371_2 top:315 top:348 29.2153
R1372_2 top:314 top:345 29.2153
R1373_2 top:313 top:342 29.2153
R1374_2 top:312 top:339 29.2153
R1375_2 top:311 top:336 29.2153
R1376_2 top:310 top:333 29.2153
R1377_2 top:309 top:330 29.2153
R1378_2 top:308 top:327 29.2153
R1379_2 top:307 top:324 29.2153
R1380_2 top:306 top:321 29.2153
R1381_2 top:305 top:318 29.2153
R1382_2 top:279 top:293 0.26125
R1383_2 top:231 top:281 0.25916
R1384_2 top:228 top:293 0.9405
R1385_2 top:227 top:292 1.20175
R1386_2 top:226 top:292 1.20175
R1387_2 top:225 top:291 1.20175
R1388_2 top:224 top:291 1.20175
R1389_2 top:223 top:290 1.20175
R1390_2 top:222 top:290 1.20175
R1391_2 top:221 top:289 1.20175
R1392_2 top:220 top:289 1.20175
R1393_2 top:219 top:288 1.20175
R1394_2 top:218 top:288 1.20175
R1395_2 top:217 top:287 1.20175
R1396_2 top:216 top:287 1.20175
R1397_2 top:215 top:286 1.20175
R1398_2 top:214 top:286 1.20175
R1399_2 top:213 top:285 1.20175
R1400_2 top:212 top:285 1.20175
R1401_2 top:211 top:284 1.20175
R1402_2 top:210 top:284 1.20175
R1403_2 top:209 top:283 1.20175
R1404_2 top:208 top:283 1.20175
R1405_2 top:207 top:282 1.20175
R1406_2 top:206 top:282 1.20175
R1407_2 top:205 top:281 0.9405
R1408_2 top:204 top:1220 0.879556
R1409_2 top:204 top:279 30
R1410_2 top:203 top:1223 1.16637
R1411_2 top:203 top:1220 0.439778
R1412_2 top:203 top:279 30
R1413_2 top:202 top:1223 0.0956039
R1414_2 top:202 top:279 30
R1415_2 top:201 top:1202 0.879556
R1416_2 top:201 top:292 30
R1417_2 top:200 top:1205 1.16637
R1418_2 top:200 top:1202 0.439778
R1419_2 top:200 top:292 30
R1420_2 top:199 top:1205 0.0956039
R1421_2 top:199 top:292 30
R1422_2 top:198 top:1184 0.879556
R1423_2 top:198 top:291 30
R1424_2 top:197 top:1187 1.16637
R1425_2 top:197 top:1184 0.439778
R1426_2 top:197 top:291 30
R1427_2 top:196 top:1187 0.0956039
R1428_2 top:196 top:291 30
R1429_2 top:195 top:1166 0.879556
R1430_2 top:195 top:290 30
R1431_2 top:194 top:1169 1.16637
R1432_2 top:194 top:1166 0.439778
R1433_2 top:194 top:290 30
R1434_2 top:193 top:1169 0.0956039
R1435_2 top:193 top:290 30
R1436_2 top:192 top:1148 0.879556
R1437_2 top:192 top:289 30
R1438_2 top:191 top:1151 1.16637
R1439_2 top:191 top:1148 0.439778
R1440_2 top:191 top:289 30
R1441_2 top:190 top:1151 0.0956039
R1442_2 top:190 top:289 30
R1443_2 top:189 top:1130 0.879556
R1444_2 top:189 top:288 30
R1445_2 top:188 top:1133 1.16637
R1446_2 top:188 top:1130 0.439778
R1447_2 top:188 top:288 30
R1448_2 top:187 top:1133 0.0956039
R1449_2 top:187 top:288 30
R1450_2 top:186 top:1112 0.879556
R1451_2 top:186 top:287 30
R1452_2 top:185 top:1115 1.16637
R1453_2 top:185 top:1112 0.439778
R1454_2 top:185 top:287 30
R1455_2 top:184 top:1115 0.0956039
R1456_2 top:184 top:287 30
R1457_2 top:183 top:1094 0.879556
R1458_2 top:183 top:286 30
R1459_2 top:182 top:1097 1.16637
R1460_2 top:182 top:1094 0.439778
R1461_2 top:182 top:286 30
R1462_2 top:181 top:1097 0.0956039
R1463_2 top:181 top:286 30
R1464_2 top:180 top:1076 0.879556
R1465_2 top:180 top:285 30
R1466_2 top:179 top:1079 1.16637
R1467_2 top:179 top:1076 0.439778
R1468_2 top:179 top:285 30
R1469_2 top:178 top:1079 0.0956039
R1470_2 top:178 top:285 30
R1471_2 top:177 top:1058 0.879556
R1472_2 top:177 top:284 30
R1473_2 top:176 top:1061 1.16637
R1474_2 top:176 top:1058 0.439778
R1475_2 top:176 top:284 30
R1476_2 top:175 top:1061 0.0956039
R1477_2 top:175 top:284 30
R1478_2 top:174 top:1040 0.879556
R1479_2 top:174 top:283 30
R1480_2 top:173 top:1043 1.16637
R1481_2 top:173 top:1040 0.439778
R1482_2 top:173 top:283 30
R1483_2 top:172 top:1043 0.0956039
R1484_2 top:172 top:283 30
R1485_2 top:171 top:1022 0.879556
R1486_2 top:171 top:282 30
R1487_2 top:170 top:1025 1.16637
R1488_2 top:170 top:1022 0.439778
R1489_2 top:170 top:282 30
R1490_2 top:169 top:1025 0.0956039
R1491_2 top:169 top:282 30
R1492_2 top:168 top:1004 0.879556
R1493_2 top:168 top:231 30
R1494_2 top:167 top:1007 1.16637
R1495_2 top:167 top:1004 0.439778
R1496_2 top:167 top:231 30
R1497_2 top:166 top:1007 0.0956039
R1498_2 top:166 top:231 30
R1499_2 top:127 top:141 0.26125
R1500_2 top:79 top:129 0.25916
R1501_2 top:76 top:141 0.9405
R1502_2 top:75 top:140 1.20175
R1503_2 top:74 top:140 1.20175
R1504_2 top:73 top:139 1.20175
R1505_2 top:72 top:139 1.20175
R1506_2 top:71 top:138 1.20175
R1507_2 top:70 top:138 1.20175
R1508_2 top:69 top:137 1.20175
R1509_2 top:68 top:137 1.20175
R1510_2 top:67 top:136 1.20175
R1511_2 top:66 top:136 1.20175
R1512_2 top:65 top:135 1.20175
R1513_2 top:64 top:135 1.20175
R1514_2 top:63 top:134 1.20175
R1515_2 top:62 top:134 1.20175
R1516_2 top:61 top:133 1.20175
R1517_2 top:60 top:133 1.20175
R1518_2 top:59 top:132 1.20175
R1519_2 top:58 top:132 1.20175
R1520_2 top:57 top:131 1.20175
R1521_2 top:56 top:131 1.20175
R1522_2 top:55 top:130 1.20175
R1523_2 top:54 top:130 1.20175
R1524_2 top:53 top:129 0.9405
R1525_2 top:52 top:1211 0.879556
R1526_2 top:52 top:127 30
R1527_2 top:51 top:1214 1.16637
R1528_2 top:51 top:1211 0.439778
R1529_2 top:51 top:127 30
R1530_2 top:50 top:1214 0.0956039
R1531_2 top:50 top:127 30
R1532_2 top:49 top:1193 0.879556
R1533_2 top:49 top:140 30
R1534_2 top:48 top:1196 1.16637
R1535_2 top:48 top:1193 0.439778
R1536_2 top:48 top:140 30
R1537_2 top:47 top:1196 0.0956039
R1538_2 top:47 top:140 30
R1539_2 top:46 top:1175 0.879556
R1540_2 top:46 top:139 30
R1541_2 top:45 top:1178 1.16637
R1542_2 top:45 top:1175 0.439778
R1543_2 top:45 top:139 30
R1544_2 top:44 top:1178 0.0956039
R1545_2 top:44 top:139 30
R1546_2 top:43 top:1157 0.879556
R1547_2 top:43 top:138 30
R1548_2 top:42 top:1160 1.16637
R1549_2 top:42 top:1157 0.439778
R1550_2 top:42 top:138 30
R1551_2 top:41 top:1160 0.0956039
R1552_2 top:41 top:138 30
R1553_2 top:40 top:1139 0.879556
R1554_2 top:40 top:137 30
R1555_2 top:39 top:1142 1.16637
R1556_2 top:39 top:1139 0.439778
R1557_2 top:39 top:137 30
R1558_2 top:38 top:1142 0.0956039
R1559_2 top:38 top:137 30
R1560_2 top:37 top:1121 0.879556
R1561_2 top:37 top:136 30
R1562_2 top:36 top:1124 1.16637
R1563_2 top:36 top:1121 0.439778
R1564_2 top:36 top:136 30
R1565_2 top:35 top:1124 0.0956039
R1566_2 top:35 top:136 30
R1567_2 top:34 top:1103 0.879556
R1568_2 top:34 top:135 30
R1569_2 top:33 top:1106 1.16637
R1570_2 top:33 top:1103 0.439778
R1571_2 top:33 top:135 30
R1572_2 top:32 top:1106 0.0956039
R1573_2 top:32 top:135 30
R1574_2 top:31 top:1085 0.879556
R1575_2 top:31 top:134 30
R1576_2 top:30 top:1088 1.16637
R1577_2 top:30 top:1085 0.439778
R1578_2 top:30 top:134 30
R1579_2 top:29 top:1088 0.0956039
R1580_2 top:29 top:134 30
R1581_2 top:28 top:1067 0.879556
R1582_2 top:28 top:133 30
R1583_2 top:27 top:1070 1.16637
R1584_2 top:27 top:1067 0.439778
R1585_2 top:27 top:133 30
R1586_2 top:26 top:1070 0.0956039
R1587_2 top:26 top:133 30
R1588_2 top:25 top:1049 0.879556
R1589_2 top:25 top:132 30
R1590_2 top:24 top:1052 1.16637
R1591_2 top:24 top:1049 0.439778
R1592_2 top:24 top:132 30
R1593_2 top:23 top:1052 0.0956039
R1594_2 top:23 top:132 30
R1595_2 top:22 top:1031 0.879556
R1596_2 top:22 top:131 30
R1597_2 top:21 top:1034 1.16637
R1598_2 top:21 top:1031 0.439778
R1599_2 top:21 top:131 30
R1600_2 top:20 top:1034 0.0956039
R1601_2 top:20 top:131 30
R1602_2 top:19 top:1013 0.879556
R1603_2 top:19 top:130 30
R1604_2 top:18 top:1016 1.16637
R1605_2 top:18 top:1013 0.439778
R1606_2 top:18 top:130 30
R1607_2 top:17 top:1016 0.0956039
R1608_2 top:17 top:130 30
R1609_2 top:16 top:995 0.879556
R1610_2 top:16 top:79 30
R1611_2 top:15 top:998 1.16637
R1612_2 top:15 top:995 0.439778
R1613_2 top:15 top:79 30
R1614_2 top:14 top:998 0.0956039
R1615_2 top:14 top:79 30
R1616_2 top:2 top:1737 13.464
R1617_2 top:2 top:1732 0.561
** top 1.81435e-14 *
C1105 XI0/MM2:g XI0/MM2:d 0.0188566f
C1106 XI0/MM1:g XI0/MM1:d 0.0242774f
C1107 enable:37 enableb:21 0.0259523f
C1108 enable:37 enableb:50 5.12832e-19
C1109 enable:37 XI0/MM2:d 6.43659e-19
C1110 enable:50 XI0/MM1:d 7.42436e-19
C1111 enable:58 enableb:84 6.97197e-19
C1112 enable:64 enableb:26 0.00192896f
C1113 enable:64 enableb:36 0.00137098f
C1114 enable:64 enableb:63 6.28487e-19
C1115 enable:64 enableb:68 0.00553551f
C1116 enable:64 enableb:84 0.00389707f
C1117 enable:74 enableb:30 0.0104882f
C1118 enable:74 enableb:48 0.00175051f
C1119 enable:74 enableb:73 0.00407583f
C1120 enable:81 enableb:48 6.76313e-19
C1121 enable:81 enableb:68 0.00534578f
C1122 enable:81 enableb:73 0.00709491f
C1123 enable:81 enableb:84 0.163619f
C1124 enable:90 enableb:21 2.80231e-19
C1125 XI0/MM2:g vssd:124 0.00137921f
C1126 XI0/MM2:g vssd:223 0.0188566f
C1127 XI0/MM2:g vssd:313 5.31272e-19
C1128 MM7:g vssd:313 4.85236e-19
C1129 MM7@2:g vssd:313 4.85236e-19
C1130 enable:37 vssd:70 0.00135941f
C1131 enable:37 vssd:113 4.75011e-19
C1132 enable:37 vssd:117 2.23779e-19
C1133 enable:37 vssd:124 0.00449823f
C1134 enable:37 vssd:140 0.0021298f
C1135 enable:37 vssd:144 2.58042e-19
C1136 enable:37 vssd:223 0.00220084f
C1137 enable:50 vssd:82 8.46965e-19
C1138 enable:58 vssd:82 0.0594498f
C1139 enable:58 vssd:117 5.65366e-19
C1140 enable:64 vssd:70 0.00181655f
C1141 enable:64 vssd:117 0.00157048f
C1142 enable:64 vssd:124 0.00106227f
C1143 enable:74 vssd:82 0.00208104f
C1144 enable:81 vssd:82 0.0156904f
C1145 enable:81 vssd:117 0.00853403f
C1146 enable:90 vssd:70 4.39935e-19
C1147 enable:103 vssd:82 2.36371e-19
C1148 XI0/MM1:g vddd:248 0.00178698f
C1149 XI0/MM1:g vddd:589 4.76457e-19
C1150 XI0/MM1:g vddd:646 7.83387e-19
C1151 XI0/MM1:g MM9:s 0.0242774f
C1152 MM9:g vddd:248 7.29957e-19
C1153 MM9:g vddd:646 7.83387e-19
C1154 MM9:g MM9:s 0.0242774f
C1155 MM9@2:g vddd:261 7.29957e-19
C1156 MM9@2:g vddd:646 7.83387e-19
C1157 MM9@2:g MM2:s 0.0242774f
C1158 enable:50 vddd:248 0.00637909f
C1159 enable:50 vddd:252 2.8125e-19
C1160 enable:50 vddd:589 4.24374e-19
C1161 enable:50 MM9:s 0.00332066f
C1162 enable:50 MM2:s 9.10404e-19
C1163 enable:74 vddd:248 0.001063f
C1164 enable:74 vddd:252 2.13042e-19
C1165 enable:74 vddd:589 5.35115e-19
C1166 MM7:g net8:3 6.53023e-19
C1167 MM7:g MM7:s 0.0155342f
C1168 MM7@2:g net8:12 6.53023e-19
C1169 MM7@2:g net8:51 0.0155342f
C1170 enable:37 net8:3 0.00444907f
C1171 enable:37 net8:6 0.00112504f
C1172 enable:37 MM7:s 0.00211259f
C1173 enable:37 net8:51 6.70913e-19
C1174 enable:64 net8:3 0.00106227f
C1175 XI0/MM2:g net13:180 0.00237134f
C1176 enable:37 net13:78 0.00126592f
C1177 enable:37 net13:180 0.00186208f
C1178 enable:58 net13:71 2.31763e-19
C1179 enable:58 net13:154 7.73104e-19
C1180 enable:64 net13:78 2.42876e-19
C1181 enable:64 net13:180 0.00558273f
C1182 enable:81 net13:180 0.0047009f
C1183 enable:90 net13:180 7.03599e-19
C1184 MM7:g net5:82 6.29573e-19
C1185 MM7:g MM7@2:d 0.0155342f
C1186 MM7@2:g net5:82 3.21744e-19
C1187 MM7@2:g MM7@2:d 0.0155342f
C1188 MM9:g net5:90 0.00100354f
C1189 MM9:g MM9@2:d 0.0242774f
C1190 MM9@2:g net5:90 3.03603e-19
C1191 MM9@2:g MM9@2:d 0.0242774f
C1192 enable:37 net5:18 0.00472019f
C1193 enable:37 net5:82 2.04278e-19
C1194 enable:37 MM7@2:d 0.00273613f
C1195 enable:50 net5:24 0.00747791f
C1196 enable:50 net5:90 0.00148965f
C1197 enable:50 MM9@2:d 0.00306286f
C1198 enable:64 net5:18 2.98269e-19
C1199 enable:64 net5:82 0.00477898f
C1200 enable:64 net5:84 5.16487e-19
C1201 enable:74 net5:24 0.00103772f
C1202 enable:74 net5:90 0.00484035f
C1203 enable:74 net5:92 4.15833e-19
C1204 enable:81 net5:90 6.51524e-19
C138_3 enable:111 0 0.00372306f
C139_3 enable:107 0 0.00403925f
C140_3 enable:103 0 0.00780726f
C141_3 enable:98 0 0.0085957f
C142_3 enable:94 0 0.0087333f
C143_3 enable:90 0 0.0143552f
C144_2 enable:81 0 0.0424243f
C145_2 enable:74 0 0.0233152f
C146_2 enable:64 0 0.0160185f
C147_2 enable:58 0 0.0239608f
C148_2 enable:50 0 0.0131133f
C149_2 enable:37 0 0.0225244f
C150_2 enable:15 0 0.00146713f
C151_2 enable:14 0 0.00204517f
C152_2 enable:13 0 0.00818429f
C153_2 enable:3 0 0.00725076f
C154_2 enable:2 0 0.00732773f
C155_2 enable:1 0 0.0135705f
R156_2 enable:86 enable:87 0.8705
R157_2 enable:84 enable:87 4.31126
R158_2 enable:81 enable:84 7.07765
R159_2 enable:75 enable:76 0.171463
R160_2 enable:74 enable:76 2.0688
R161_2 enable:71 enable:86 8
R162_2 enable:71 enable:75 0.50899
R163_2 enable:65 enable:66 0.358932
R164_2 enable:64 enable:66 1.05707
R165_2 enable:61 enable:81 8
R166_2 enable:61 enable:65 0.528537
R167_2 enable:58 enable:84 8
R168_2 enable:54 enable:58 3.47684
R169_2 enable:51 enable:52 0.189732
R170_2 enable:50 enable:111 133.333
R171_2 enable:50 enable:52 0.123438
R172_2 enable:46 enable:47 0.189732
R173_2 enable:45 enable:74 4.5
R174_2 enable:45 enable:107 133.333
R175_2 enable:45 enable:51 0.123438
R176_2 enable:45 enable:47 0.123438
R177_2 enable:42 enable:103 133.333
R178_2 enable:42 enable:46 0.123438
R179_2 enable:38 enable:39 0.189732
R180_2 enable:37 enable:98 133.333
R181_2 enable:37 enable:39 0.123683
R182_2 enable:34 enable:35 0.189732
R183_2 enable:33 enable:94 133.333
R184_2 enable:33 enable:38 0.123683
R185_2 enable:33 enable:35 0.123683
R186_2 enable:30 enable:31 0.189732
R187_2 enable:29 enable:64 2.25
R188_2 enable:29 enable:34 0.448351
R189_2 enable:29 enable:31 0.200985
R190_2 enable:26 enable:90 133.333
R191_2 enable:26 enable:30 0.123683
R192_2 enable:23 enable:111 239.879
R193 enable:20 enable:107 239.879
R194 enable:17 enable:103 239.879
R195 enable:15 enable:23 479.758
R196 enable:14 enable:20 479.758
R197 enable:13 enable:17 479.758
R198 enable:10 enable:98 137.532
R199 enable:7 enable:94 137.532
R200 enable:4 enable:90 137.532
R201 enable:3 enable:10 137.532
R202 enable:2 enable:7 137.532
R203 enable:1 enable:4 137.532
** enable 1.3012e-15 *
C1205 vddd_esd enableb:84 0.010008f
C1206 MM12<1>:g vssd:313 0.00252658f
C1207 MM12<1>==2:g vssd:313 0.00252658f
C1208 MM12<1>==3:g vssd:313 0.00252658f
C1209 MM12<1>==4:g vssd:313 0.00252658f
C1210 vddd_esd vssd:120 0.0460324f
C1211 vddd_esd:65 vddd:291 0.00119995f
C1212 vddd_esd:76 vddd:589 2.14198e-19
C1213 vddd_esd vddd:261 0.00908718f
C1214 vddd_esd vddd:265 0.0101363f
C1215 vddd_esd vddd:274 0.00885671f
C1216 MM12<1>:g net13:6 0.00192705f
C1217 MM12<1>:g net13:19 0.0190047f
C1218 MM12<1>:g net13:93 0.00203288f
C1219 MM12<1>==2:g net13:7 0.00151223f
C1220 MM12<1>==2:g net13:20 0.0190047f
C1221 MM12<1>==2:g net13:93 0.00203288f
C1222 MM12<1>==3:g net13:7 0.00151223f
C1223 MM12<1>==3:g net13:20 0.0190047f
C1224 MM12<1>==3:g net13:119 0.00203288f
C1225 MM12<1>==4:g net13:8 0.00192705f
C1226 MM12<1>==4:g net13:17 0.0190047f
C1227 MM12<1>==4:g net13:119 0.00203288f
C1228 MM12<0>:g net13:22 0.00192705f
C1229 MM12<0>:g net13:35 0.0190047f
C1230 MM12<0>:g net13:97 0.00203288f
C1231 MM12<0>==2:g net13:23 0.00238571f
C1232 MM12<0>==2:g net13:36 0.0190047f
C1233 MM12<0>==2:g net13:97 0.00203288f
C1234 MM12<0>==3:g net13:23 0.00238571f
C1235 MM12<0>==3:g net13:36 0.0190047f
C1236 MM12<0>==3:g net13:123 0.00203288f
C1237 MM12<0>==4:g net13:24 0.00192514f
C1238 MM12<0>==4:g net13:33 0.0190047f
C1239 MM12<0>==4:g net13:123 0.00203288f
C1240 vddd_esd:65 net13:7 0.00367491f
C1241 vddd_esd:65 net13:17 0.00105239f
C1242 vddd_esd:65 net13:19 0.00105239f
C1243 vddd_esd:65 net13:20 0.00553031f
C1244 vddd_esd:65 net13:23 0.00377295f
C1245 vddd_esd:65 net13:33 0.00107578f
C1246 vddd_esd:65 net13:35 0.00107578f
C1247 vddd_esd:65 net13:36 0.00560807f
C1248 vddd_esd:65 net13:71 0.00631781f
C1249 vddd_esd:65 net13:93 0.00625732f
C1250 vddd_esd:65 net13:97 0.0063052f
C1251 vddd_esd:65 net13:119 0.00610358f
C1252 vddd_esd:65 net13:123 0.00601794f
C1253 vddd_esd:65 net13:139 0.00704066f
C1254 vddd_esd:65 net13:154 0.00116396f
C1255 vddd_esd:76 net13:7 3.8477e-19
C1256 vddd_esd:76 net13:23 3.87432e-19
C1257 vddd_esd:76 net13:71 3.30966e-19
C1258 vddd_esd:76 net13:139 6.04469e-19
C1259 vddd_esd:76 net13:154 0.00103614f
C1260 vddd_esd:76 net13:180 3.64801e-19
C1261 vddd_esd net13:23 0.0094783f
C1262 vddd_esd net13:36 0.00250456f
C1263 vddd_esd net13:97 0.00102536f
C1264 vddd_esd net13:123 6.48038e-19
C1265 vddd_esd net13:139 0.00119435f
C1266 vddd_esd net13:146 5.8451e-19
C1267 vddd_esd net13:154 0.0014282f
C1268 vddd_esd net13:180 0.00319573f
C1269 vddd_esd:82 net13:154 3.3891e-19
C1270 vddd_esd:82 net13:180 0.00250436f
C1271 vddd_esd:96 net13:71 0.00275109f
C1272 vddd_esd:108 net13:139 0.00304881f
C1273 vddd_esd:76 net5:93 6.28436e-19
C1274 vddd_esd:76 net5:155 2.03333e-19
C1275 vddd_esd net5:90 0.00987334f
C1276 vddd_esd net5:92 0.00159482f
C1277 vddd_esd net5:96 0.0191929f
C1278 vddd_esd net5:98 0.00365811f
C1279 vddd_esd net5:102 0.00703204f
C1280 vddd_esd net5:135 0.00249258f
C1281 vddd_esd MM2@4:d 0.00247478f
C1282 vddd_esd:82 net5:85 4.42359e-19
C1283 vddd_esd:91 net5:104 4.16155e-19
C1284 vddd_esd:91 net5:155 2.35278e-19
C1285 MM12<1>:g MM7:g 3.06866e-19
C1286 vddd_esd enable:50 2.83124e-19
C1287 vddd_esd enable:74 4.88586e-19
C1288 vddd_esd enable:81 0.00437352f
C139_4 vddd_esd:108 0 0.01923f
C140_4 vddd_esd:104 0 0.0138079f
C141_4 vddd_esd:100 0 0.0138079f
C142_4 vddd_esd:96 0 0.0190204f
C143_4 vddd_esd:93 0 0.0023334f
C144_3 vddd_esd:91 0 0.0157492f
C145_3 vddd_esd:82 0 0.014802f
C146_3 vddd_esd:81 0 0.244535f
C147_3 vddd_esd:76 0 0.00331821f
C148_3 vddd_esd:65 0 0.0156017f
C149_3 vddd_esd:20 0 0.0107399f
C150_3 vddd_esd:19 0 0.00645642f
C151_3 vddd_esd:18 0 0.00642773f
C152_3 vddd_esd:17 0 0.0104026f
C153_3 vddd_esd:4 0 0.00852665f
C154_3 vddd_esd:3 0 0.00468962f
C155_3 vddd_esd:2 0 0.00469998f
C156_2 vddd_esd:1 0 0.00877574f
R157_3 vddd_esd:89 vddd_esd:93 0.235
R158_3 vddd_esd:89 vddd_esd:91 0.535305
R159_3 vddd_esd:86 vddd_esd:93 0.00453472
R160_3 vddd_esd:82 vddd_esd:93 0.235
R161_3 vddd_esd:82 vddd_esd:84 0.443539
R162_3 vddd_esd:81 vddd_esd:86 17.653
R163_3 vddd_esd:76 vddd_esd:91 2.25
R164_3 vddd_esd:70 vddd_esd:84 1.5
R165_3 vddd_esd:70 vddd_esd:76 1.28507
R166_3 vddd_esd:66 vddd_esd:67 0.118952
R167_3 vddd_esd:65 vddd_esd:108 25
R168_3 vddd_esd:65 vddd_esd:67 0.176423
R169_3 vddd_esd:63 vddd_esd:76 2.25
R170_3 vddd_esd:63 vddd_esd:66 0.166045
R171_3 vddd_esd:60 vddd_esd:61 0.118952
R172_3 vddd_esd:59 vddd_esd:104 25
R173_3 vddd_esd:59 vddd_esd:63 0.23869
R174_3 vddd_esd:59 vddd_esd:61 0.176423
R175_3 vddd_esd:57 vddd_esd:70 1.5
R176_3 vddd_esd:57 vddd_esd:60 0.352847
R177_3 vddd_esd:54 vddd_esd:55 0.118952
R178_3 vddd_esd:53 vddd_esd:100 25
R179_3 vddd_esd:53 vddd_esd:57 0.0518892
R180_3 vddd_esd:53 vddd_esd:55 0.176423
R181_3 vddd_esd:50 vddd_esd:96 25
R182_3 vddd_esd:50 vddd_esd:54 0.404736
R183_3 vddd_esd:30 vddd_esd:108 71.8647
R184_3 vddd_esd:27 vddd_esd:104 71.8647
R185_3 vddd_esd:24 vddd_esd:100 71.8647
R186_3 vddd_esd:21 vddd_esd:96 71.8647
R187_3 vddd_esd:20 vddd_esd:30 47.9098
R188_3 vddd_esd:19 vddd_esd:27 47.9098
R189_3 vddd_esd:18 vddd_esd:24 47.9098
R190_3 vddd_esd:17 vddd_esd:21 47.9098
R191_3 vddd_esd:15 vddd_esd:108 35.9324
R192_3 vddd_esd:12 vddd_esd:104 35.9324
R193_2 vddd_esd:9 vddd_esd:100 35.9324
R194_2 vddd_esd:6 vddd_esd:96 35.9324
R195_2 vddd_esd:4 vddd_esd:15 47.9098
R196_2 vddd_esd:3 vddd_esd:12 47.9098
R197_2 vddd_esd:2 vddd_esd:9 47.9098
R198_2 vddd_esd:1 vddd_esd:6 47.9098
** vddd_esd 1.14475e-15 *
C1289 MM13:g MM14:g 0.00343628f
C1290 MM13@4:g MM14:g 3.29686e-19
C1291 MM5@3:g MM6:g 3.29686e-19
C1292 MM5@2:g MM6:g 0.00343628f
C1293 charge:64 enableb:5 0.00986481f
C1294 charge:64 enableb:8 7.70889e-19
C1295 charge:64 enableb:14 0.0104483f
C1296 charge:64 enableb:17 7.70889e-19
C1297 charge:64 enableb:50 0.0549536f
C1298 charge:81 enableb:5 0.0066909f
C1299 charge:81 enableb:14 0.00105868f
C1300 charge:81 enableb:21 0.00742664f
C1301 charge:81 enableb:50 0.00588609f
C1302 charge:81 enableb:63 0.0112641f
C1303 charge:81 enableb:77 0.0027192f
C1304 charge:89 enableb:5 0.00126971f
C1305 charge:89 enableb:8 0.00829763f
C1306 charge:89 enableb:50 2.08465e-19
C1307 charge:93 enableb:8 2.74578e-19
C1308 charge:113 enableb:17 2.74715e-19
C1309 charge:117 enableb:14 0.00120753f
C1310 charge:117 enableb:17 0.00830053f
C1311 charge:117 enableb:50 2.08465e-19
C1312 MM13:g vssd:144 6.33693e-19
C1313 MM13:g MM13:s 0.0155342f
C1314 MM13:g vssd:326 0.00101756f
C1315 MM13@4:g vssd:153 6.33693e-19
C1316 MM13@4:g MM13@3:s 0.0155342f
C1317 MM13@4:g vssd:326 0.00101756f
C1318 MM13@3:g vssd:153 6.33693e-19
C1319 MM13@3:g MM13@3:s 0.0155342f
C1320 MM13@3:g vssd:326 0.00101756f
C1321 MM13@2:g vssd:164 6.33693e-19
C1322 MM13@2:g MM5:s 0.0155342f
C1323 MM13@2:g vssd:326 0.00142984f
C1324 MM5:g vssd:164 6.33693e-19
C1325 MM5:g MM5:s 0.0155342f
C1326 MM5:g vssd:326 0.00142984f
C1327 MM5@4:g vssd:173 6.33693e-19
C1328 MM5@4:g MM5@3:s 0.0155342f
C1329 MM5@4:g vssd:326 0.00142984f
C1330 MM5@3:g vssd:173 6.33693e-19
C1331 MM5@3:g MM5@3:s 0.0155342f
C1332 MM5@3:g vssd:326 0.00142984f
C1333 MM5@2:g vssd:11 0.0155342f
C1334 MM5@2:g vssd:183 6.33693e-19
C1335 MM5@2:g vssd:326 0.00142984f
C1336 charge:64 vssd:11 8.64347e-19
C1337 charge:64 vssd:146 5.95508e-19
C1338 charge:64 vssd:153 0.00460501f
C1339 charge:64 vssd:155 4.70738e-19
C1340 charge:64 vssd:164 0.00460501f
C1341 charge:64 vssd:166 6.45885e-19
C1342 charge:64 vssd:173 0.00460501f
C1343 charge:64 vssd:175 6.01698e-19
C1344 charge:64 MM13:s 8.64347e-19
C1345 charge:64 MM13@3:s 0.00343482f
C1346 charge:64 MM5:s 0.00328311f
C1347 charge:64 MM5@3:s 0.00343482f
C1348 charge:81 vssd:70 0.0672267f
C1349 charge:81 vssd:113 0.00485673f
C1350 charge:81 vssd:144 7.73126e-19
C1351 charge:81 vssd:153 4.99251e-19
C1352 charge:81 vssd:155 3.14718e-19
C1353 charge:81 vssd:164 0.00106227f
C1354 charge:81 vssd:166 3.14718e-19
C1355 charge:81 vssd:173 4.86958e-19
C1356 charge:64 net8:15 4.80313e-19
C1357 MM13:g net13:169 2.08867e-19
C1358 MM13:g MM13@4:d 0.0155342f
C1359 MM13@4:g net13:169 2.08867e-19
C1360 MM13@4:g MM13@4:d 0.0155342f
C1361 MM13@3:g net13:175 2.08867e-19
C1362 MM13@3:g MM13@2:d 0.0155342f
C1363 MM13@2:g net13:175 2.08867e-19
C1364 MM13@2:g MM13@2:d 0.0155342f
C1365 charge:64 net13:102 0.00527303f
C1366 charge:64 net13:108 0.00527303f
C1367 charge:64 net13:169 2.03705e-19
C1368 charge:64 net13:171 3.8495e-19
C1369 charge:64 net13:175 2.03705e-19
C1370 charge:64 MM13@4:d 0.00283053f
C1371 charge:64 MM13@2:d 0.00283053f
C1372 charge:81 net13:1 7.81178e-19
C1373 charge:81 net13:102 6.72899e-19
C1374 charge:81 net13:108 3.3645e-19
C1375 charge:81 net13:149 0.00449319f
C1376 charge:81 net13:163 0.00474087f
C1377 charge:81 net13:165 0.0019219f
C1378 charge:81 net13:169 0.00451357f
C1379 charge:81 net13:171 0.00151654f
C1380 charge:81 net13:175 0.00451357f
C1381 charge:81 net13:180 0.00590696f
C1382 MM5:g bot:1472 2.08628e-19
C1383 MM5:g MM5@4:d 0.0155342f
C1384 MM5@4:g bot:1472 2.08628e-19
C1385 MM5@4:g bot:1474 5.44092e-19
C1386 MM5@4:g MM5@4:d 0.0155342f
C1387 MM5@3:g bot:1474 5.44092e-19
C1388 MM5@3:g bot:1484 2.08628e-19
C1389 MM5@3:g MM5@2:d 0.0155342f
C1390 MM5@2:g bot:1484 2.08628e-19
C1391 MM5@2:g bot:1486 5.44092e-19
C1392 MM5@2:g MM5@2:d 0.0155342f
C1393 charge:64 bot:805 0.00527303f
C1394 charge:64 bot:817 0.00527303f
C1395 charge:64 bot:1472 2.03561e-19
C1396 charge:64 bot:1474 3.68862e-19
C1397 charge:64 bot:1484 2.03561e-19
C1398 charge:64 MM5@4:d 0.00283053f
C1399 charge:64 MM5@2:d 0.00283053f
C1400 charge:81 bot:805 3.3645e-19
C1401 charge:81 bot:817 6.72899e-19
C1402 charge:81 bot:1472 0.00453496f
C1403 charge:81 bot:1474 0.00161928f
C1404 charge:81 bot:1484 0.00453425f
C1405 charge:81 bot:1486 7.67304e-19
C1406 charge:81 bot:1831 6.32803e-19
C1407 charge:64 enable:37 7.35489e-19
C1408 charge:81 enable:64 0.00107431f
C1409 charge:89 enable:94 0.00150382f
C1410 charge:93 enable:98 0.0015286f
C131_3 charge:117 0 0.00376053f
C132_3 charge:113 0 0.00347018f
C133_3 charge:109 0 0.00340566f
C134_3 charge:105 0 0.0034034f
C135_3 charge:101 0 0.0045483f
C136_3 charge:97 0 0.00455056f
C137_3 charge:93 0 0.00347018f
C138_4 charge:89 0 0.00372613f
C139_5 charge:81 0 0.0511275f
C140_5 charge:64 0 0.0162469f
C141_5 charge:8 0 0.00262162f
C142_5 charge:7 0 0.00257527f
C143_5 charge:6 0 0.00257527f
C144_4 charge:5 0 0.00203091f
C145_4 charge:4 0 0.00203091f
C146_4 charge:3 0 0.00194816f
C147_4 charge:2 0 0.00194816f
C148_4 charge:1 0 0.00199451f
R149_2 charge:82 charge:83 0.166356
R150_2 charge:81 charge:83 0.532338
R151_2 charge:78 charge:79 0.698694
R152_2 charge:77 charge:78 0.166356
R153_2 charge:76 charge:77 0.698694
R154_2 charge:75 charge:76 0.166356
R155_2 charge:74 charge:75 0.981499
R156_3 charge:73 charge:74 0.681829
R157_4 charge:72 charge:82 0.698694
R158_4 charge:72 charge:79 0.166356
R159_4 charge:68 charge:73 3.60992
R160_4 charge:65 charge:66 0.216013
R161_4 charge:64 charge:117 133.333
R162_4 charge:64 charge:66 0.142294
R163_4 charge:62 charge:113 133.333
R164_4 charge:62 charge:65 0.142294
R165_4 charge:59 charge:60 0.216013
R166_4 charge:58 charge:81 4.5
R167_4 charge:58 charge:62 0.0355734
R168_4 charge:58 charge:60 0.10672
R169_4 charge:55 charge:56 0.216013
R170_4 charge:54 charge:109 133.333
R171_4 charge:54 charge:59 0.142294
R172_4 charge:54 charge:56 0.142294
R173_4 charge:51 charge:52 0.216013
R174_4 charge:50 charge:105 133.333
R175_4 charge:50 charge:55 0.142294
R176_4 charge:50 charge:52 0.142294
R177_4 charge:48 charge:101 133.333
R178_4 charge:48 charge:51 0.142294
R179_4 charge:45 charge:72 1.5
R180_4 charge:45 charge:48 0.142294
R181_4 charge:45 charge:46 0.216013
R182_4 charge:42 charge:43 0.216013
R183_4 charge:41 charge:97 133.333
R184_4 charge:41 charge:46 0.142294
R185_4 charge:41 charge:43 0.142294
R186_4 charge:38 charge:39 0.216013
R187_4 charge:37 charge:93 133.333
R188_4 charge:37 charge:42 0.142294
R189_4 charge:37 charge:39 0.142294
R190_4 charge:34 charge:89 133.333
R191_4 charge:34 charge:38 0.142294
R192_4 charge:31 charge:117 137.532
R193_3 charge:28 charge:113 137.532
R194_3 charge:25 charge:109 137.532
R195_3 charge:22 charge:105 137.532
R196_3 charge:19 charge:101 137.532
R197_3 charge:16 charge:97 137.532
R198_3 charge:13 charge:93 137.532
R199_2 charge:10 charge:89 137.532
R200_2 charge:8 charge:31 137.532
R201_2 charge:7 charge:28 137.532
R202_2 charge:6 charge:25 137.532
R203_2 charge:5 charge:22 137.532
R204 charge:4 charge:19 137.532
R205 charge:3 charge:16 137.532
R206 charge:2 charge:13 137.532
R207 charge:1 charge:10 137.532
** charge 7.61629e-16 *
C1411 vboost:185 enableb:84 3.73468e-19
C1412 vboost:188 vssd:140 0.010601f
C1413 vboost:242 vssd:120 0.0659808f
C1414 MM0:g vddd:616 4.84137e-19
C1415 MM0:g MM0@4:d 0.0121529f
C1416 MM0@4:g vddd:616 2.27842e-19
C1417 MM0@4:g MM0@4:d 0.0121529f
C1418 MM0@3:g vddd:628 2.27842e-19
C1419 MM0@3:g MM0@2:d 0.0121529f
C1420 MM0@2:g vddd:628 5.16198e-19
C1421 MM0@2:g MM0@2:d 0.0121529f
C1422 vboost:109 vddd:296 0.0012124f
C1423 vboost:146 vddd:530 0.00493085f
C1424 vboost:146 vddd:610 4.97434e-19
C1425 vboost:146 vddd:616 0.00686066f
C1426 vboost:146 vddd:622 2.2354e-19
C1427 vboost:146 MM0@4:d 0.00303674f
C1428 vboost:156 vddd:616 0.00933867f
C1429 vboost:156 vddd:622 7.64421e-19
C1430 vboost:156 vddd:628 0.00764393f
C1431 vboost:166 vddd:536 0.00493085f
C1432 vboost:166 vddd:622 4.63934e-19
C1433 vboost:166 vddd:628 0.00751826f
C1434 vboost:166 MM0@2:d 0.00349384f
C1435 vboost:189 vddd:590 0.00628977f
C1436 vboost:190 vddd:252 0.00628977f
C1437 vboost:199 vddd:296 0.0562715f
C1438 vboost:205 vddd:296 0.0665594f
C1439 vboost:205 vddd:592 0.00628977f
C1440 vboost:213 vddd:530 2.62236e-19
C1441 vboost:213 vddd:610 4.96625e-19
C1442 vboost:213 vddd:616 0.00690141f
C1443 vboost:218 vddd:616 0.0270673f
C1444 vboost:218 vddd:622 0.0036349f
C1445 vboost:218 vddd:628 0.0264709f
C1446 vboost:228 vddd:591 0.00628977f
C1447 vboost:230 vddd:296 0.00146863f
C1448 vboost:235 vddd:296 0.00146863f
C1449 vboost:242 vddd:437 0.0642086f
C1450 vboost:242 vddd:597 0.0755318f
C1451 vboost:242 vddd:610 0.0388604f
C1452 vboost:253 vddd:296 0.0195359f
C1453 vboost:255 vddd:610 0.0436889f
C1454 vboost:264 vddd:616 0.00879634f
C1455 vboost:266 vddd:616 0.0112467f
C1456 vboost:266 vddd:622 0.00242378f
C1457 vboost:270 vddd:616 0.00381131f
C1458 vboost:270 vddd:628 0.00408534f
C1459 vboost:278 vddd:296 0.0755318f
C1460 vboost:316 vddd:616 4.8646e-19
C1461 vboost:320 vddd:616 2.72438e-19
C1462 vboost:324 vddd:628 2.72438e-19
C1463 vboost:328 vddd:628 6.88076e-19
C1464 vboost:1 net13:93 0.00402917f
C1465 vboost:2 net13:119 0.00402917f
C1466 vboost:11 net13:19 0.00811786f
C1467 vboost:11 net13:20 0.00811786f
C1468 vboost:11 net13:93 0.00494294f
C1469 vboost:12 net13:17 0.00811786f
C1470 vboost:12 net13:20 0.00811786f
C1471 vboost:12 net13:119 0.00494294f
C1472 vboost:13 net13:97 0.00402374f
C1473 vboost:14 net13:123 0.00402374f
C1474 vboost:23 net13:35 0.00811786f
C1475 vboost:23 net13:36 0.00811786f
C1476 vboost:23 net13:97 0.00494294f
C1477 vboost:24 net13:33 0.00811786f
C1478 vboost:24 net13:36 0.00811786f
C1479 vboost:24 net13:123 0.00494294f
C1480 vboost:181 net13:6 0.00267844f
C1481 vboost:181 net13:7 0.00290803f
C1482 vboost:181 net13:93 0.00576602f
C1483 vboost:181 net13:154 0.00224988f
C1484 vboost:181 net13:180 0.00293406f
C1485 vboost:185 net13:22 0.00267844f
C1486 vboost:185 net13:23 0.0018662f
C1487 vboost:185 net13:97 0.00628781f
C1488 vboost:185 net13:154 0.00224988f
C1489 vboost:185 net13:180 0.00213977f
C1490 vboost:187 net13:93 0.00932809f
C1491 vboost:188 net13:180 0.00134079f
C1492 vboost:189 net13:97 0.0128478f
C1493 vboost:193 net13:7 0.00290803f
C1494 vboost:193 net13:8 0.00374819f
C1495 vboost:193 net13:119 0.00588419f
C1496 vboost:197 net13:23 0.0018662f
C1497 vboost:197 net13:24 0.00447371f
C1498 vboost:197 net13:123 0.00655357f
C1499 vboost:199 net13:119 0.0116413f
C1500 vboost:205 net13:123 0.0156575f
C1501 MM10:g net5:124 3.83852e-19
C1502 MM10:g MM10@4:d 0.0155342f
C1503 MM10@4:g net5:124 2.08867e-19
C1504 MM10@4:g MM10@4:d 0.0155342f
C1505 MM10@3:g net5:131 2.08867e-19
C1506 MM10@3:g MM10@2:d 0.0155342f
C1507 MM10@2:g net5:131 4.73193e-19
C1508 MM10@2:g MM10@2:d 0.0155342f
C1509 MM0:g MM1@3:g 2.05052e-19
C1510 MM0:g MM1@2:g 0.00187048f
C1511 MM0@4:g MM1@2:g 2.05052e-19
C1512 vboost:109 net5:68 0.00469144f
C1513 vboost:109 net5:124 8.35594e-19
C1514 vboost:109 MM10@4:d 0.00280463f
C1515 vboost:135 net5:47 0.00511304f
C1516 vboost:141 net5:63 0.00511304f
C1517 vboost:146 net5:63 0.0142898f
C1518 vboost:146 net5:120 2.20818e-19
C1519 vboost:146 net5:177 6.88321e-19
C1520 vboost:156 net5:57 0.00111101f
C1521 vboost:172 net5:74 0.00469144f
C1522 vboost:172 net5:131 0.00106852f
C1523 vboost:172 MM10@2:d 0.00199125f
C1524 vboost:178 MM10@2:d 8.53882e-19
C1525 vboost:188 net5:85 0.0283782f
C1526 vboost:189 net5:93 0.0102858f
C1527 vboost:193 net5:155 0.00109346f
C1528 vboost:197 net5:155 0.00438491f
C1529 vboost:199 net5:106 0.00139542f
C1530 vboost:199 net5:138 0.00591363f
C1531 vboost:199 net5:155 0.0097671f
C1532 vboost:205 net5:106 0.00826727f
C1533 vboost:205 net5:136 0.0102858f
C1534 vboost:205 net5:143 4.61997e-19
C1535 vboost:205 net5:148 7.47878e-19
C1536 vboost:205 net5:155 0.0140849f
C1537 vboost:208 net5:47 3.24262e-19
C1538 vboost:208 net5:110 0.00533746f
C1539 vboost:208 net5:112 2.43015e-19
C1540 vboost:208 net5:114 0.00245789f
C1541 vboost:213 net5:63 7.07002e-19
C1542 vboost:213 net5:112 2.43104e-19
C1543 vboost:227 net5:84 0.0283782f
C1544 vboost:228 net5:135 0.0102858f
C1545 vboost:230 net5:124 2.90971e-19
C1546 vboost:230 net5:155 7.55756e-19
C1547 vboost:235 net5:106 4.74122e-19
C1548 vboost:235 net5:110 0.0113681f
C1549 vboost:242 net5:148 0.00152992f
C1550 vboost:247 net5:106 0.0186406f
C1551 vboost:247 net5:110 0.0232115f
C1552 vboost:247 net5:124 0.00542518f
C1553 vboost:247 net5:138 9.47211e-19
C1554 vboost:247 net5:143 4.57196e-19
C1555 vboost:247 net5:155 0.00629399f
C1556 vboost:251 net5:110 0.0283371f
C1557 vboost:251 net5:155 0.00188702f
C1558 vboost:252 net5:124 5.95203e-19
C1559 vboost:254 net5:115 0.00833426f
C1560 vboost:258 net5:47 0.00244047f
C1561 vboost:258 net5:110 0.00427746f
C1562 vboost:258 net5:112 5.10947e-19
C1563 vboost:258 net5:114 0.00675364f
C1564 vboost:258 net5:120 0.0036673f
C1565 vboost:258 net5:165 2.17589e-19
C1566 vboost:260 net5:57 7.78647e-19
C1567 vboost:260 net5:63 4.03396e-19
C1568 vboost:260 net5:114 0.00221854f
C1569 vboost:264 net5:63 0.00239268f
C1570 vboost:264 net5:112 5.10947e-19
C1571 vboost:264 net5:120 0.00315329f
C1572 vboost:264 net5:177 2.14244e-19
C1573 vboost:266 net5:63 4.80904e-19
C1574 vboost:278 net5:106 0.030223f
C1575 vboost:278 net5:155 0.0171204f
C1576 vboost:316 net5:63 6.88321e-19
C1577 vboost:316 net5:173 3.54805e-19
C1578 vboost:316 net5:177 0.00779694f
C1579 vboost:320 net5:177 3.36927e-19
C1580 MM1@4:d MM1:g 0.0121529f
C1581 MM1@4:d MM1@4:g 0.0121529f
C1582 MM1@4:d net5:47 0.00304811f
C1583 MM1@2:d MM1@3:g 0.0121529f
C1584 MM1@2:d MM1@2:g 0.0121529f
C1585 MM1@2:d net5:63 0.00304811f
C1586 MM11:g bot:835 6.33693e-19
C1587 MM11:g MM11:s 0.0155342f
C1588 MM11:g bot:2312 7.56738e-19
C1589 MM11@4:g bot:840 6.33693e-19
C1590 MM11@4:g MM11@3:s 0.0155342f
C1591 MM11@4:g bot:2312 7.56738e-19
C1592 MM11@3:g bot:840 6.33693e-19
C1593 MM11@3:g MM11@3:s 0.0155342f
C1594 MM11@3:g bot:2312 7.56738e-19
C1595 MM11@2:g bot:845 6.33693e-19
C1596 MM11@2:g MM10:s 0.0155342f
C1597 MM11@2:g bot:2312 7.56738e-19
C1598 MM10:g bot:845 6.33693e-19
C1599 MM10:g MM10:s 0.0155342f
C1600 MM10:g bot:2312 7.56738e-19
C1601 MM10@4:g bot:850 6.33693e-19
C1602 MM10@4:g MM10@3:s 0.0155342f
C1603 MM10@4:g bot:2312 0.00130846f
C1604 MM10@3:g bot:850 6.33693e-19
C1605 MM10@3:g MM10@3:s 0.0155342f
C1606 MM10@3:g bot:2312 0.00130846f
C1607 MM10@2:g bot:1051 6.33693e-19
C1608 MM10@2:g bot:1054 2.55729e-19
C1609 MM10@2:g bot:2167 0.0155342f
C1610 MM10@2:g bot:2312 0.00186018f
C1611 MM0@2:g bot:1840 0.0017307f
C1612 vboost:109 bot:840 0.00533356f
C1613 vboost:109 bot:845 0.00533356f
C1614 vboost:109 bot:850 0.00568861f
C1615 vboost:109 bot:1054 0.0022502f
C1616 vboost:109 bot:1827 8.20191e-19
C1617 vboost:109 MM11:s 8.64347e-19
C1618 vboost:109 MM11@3:s 0.00332862f
C1619 vboost:109 MM10:s 0.00328311f
C1620 vboost:109 MM10@3:s 0.00181406f
C1621 vboost:160 bot:1521 5.92131e-19
C1622 vboost:166 bot:1840 0.00229576f
C1623 vboost:172 bot:266 0.00117065f
C1624 vboost:172 bot:1521 2.67998e-19
C1625 vboost:172 bot:2167 8.34006e-19
C1626 vboost:178 bot:1054 9.48722e-19
C1627 vboost:178 MM10@3:s 0.00171835f
C1628 vboost:187 bot:1480 0.00122691f
C1629 vboost:193 bot:1822 5.91558e-19
C1630 vboost:193 bot:1831 0.00225962f
C1631 vboost:199 bot:1492 0.00122691f
C1632 vboost:199 bot:1822 0.00724377f
C1633 vboost:199 bot:1828 0.0552423f
C1634 vboost:199 bot:1831 0.0107666f
C1635 vboost:205 bot:1822 6.60945e-19
C1636 vboost:205 bot:1828 0.00249405f
C1637 vboost:205 bot:1831 4.99368e-19
C1638 vboost:218 bot:1840 4.99559e-19
C1639 vboost:223 bot:266 4.86787e-19
C1640 vboost:223 bot:850 5.57882e-19
C1641 vboost:227 bot:1814 0.00122691f
C1642 vboost:230 bot:1054 0.00232166f
C1643 vboost:230 bot:1827 8.50932e-19
C1644 vboost:230 bot:1828 0.0078371f
C1645 vboost:247 bot:835 0.00611211f
C1646 vboost:247 bot:1054 0.00307229f
C1647 vboost:247 bot:1827 0.0027636f
C1648 vboost:247 bot:1828 0.0102985f
C1649 vboost:252 bot:835 7.67403e-19
C1650 vboost:252 bot:1054 3.88328e-19
C1651 vboost:252 bot:1827 0.00112798f
C1652 vboost:264 bot:1840 0.0030111f
C1653 vboost:270 bot:1840 0.0147088f
C1654 vboost:328 bot:1840 4.16064e-19
C1655 MM11:g in:16 4.3919e-19
C1656 MM11:g MM11@4:d 0.0155342f
C1657 MM11@4:g MM11@4:d 0.0155342f
C1658 MM11@3:g MM11@2:d 0.0155342f
C1659 MM11@2:g MM11@2:d 0.0155342f
C1660 vboost:109 in:2 0.00484398f
C1661 vboost:109 in:8 0.00484398f
C1662 vboost:109 in:16 0.00901039f
C1663 vboost:109 in:18 0.00410796f
C1664 vboost:109 in:27 0.00792928f
C1665 vboost:109 in:29 0.00809128f
C1666 vboost:109 MM11@4:d 0.00287663f
C1667 vboost:109 MM11@2:d 0.00287663f
C1668 vboost:160 in 0.00186924f
C1669 vboost:160 in:27 5.91307e-19
C1670 vboost:160 in:29 5.18366e-19
C1671 vboost:223 in 0.00483094f
C1672 vboost:223 in:27 0.00151777f
C1673 vboost:247 in:19 0.00985542f
C1674 vboost:252 in 0.0373129f
C1675 vboost:252 in:19 0.0113156f
C1676 vboost:274 in 0.00141847f
C1677 vboost:274 in:27 7.6361e-19
C1678 vboost:283 in:16 0.00100354f
C1679 vboost:287 in:16 3.03603e-19
C1680 vboost:291 in:27 3.03603e-19
C1681 vboost:295 in:27 8.60954e-19
C1682 vboost:295 in:29 2.56619e-19
C1683 vboost:299 in:29 2.56619e-19
C1684 MM0:g top:726 6.53023e-19
C1685 MM0:g top:1775 9.95058e-19
C1686 MM0:g MM0:s 0.0121529f
C1687 MM0@4:g top:731 6.53023e-19
C1688 MM0@4:g top:1775 9.95058e-19
C1689 MM0@4:g MM0@3:s 0.0121529f
C1690 MM0@3:g top:731 6.53023e-19
C1691 MM0@3:g top:1775 9.95058e-19
C1692 MM0@3:g MM0@3:s 0.0121529f
C1693 MM0@2:g top:736 6.08129e-19
C1694 MM0@2:g top:1775 9.95058e-19
C1695 MM0@2:g top:1807 0.0121529f
C1696 vboost:135 top:716 0.00437052f
C1697 vboost:135 top:721 0.0043601f
C1698 vboost:135 top:738 0.00131062f
C1699 vboost:141 top:721 0.0043601f
C1700 vboost:141 top:726 0.0043601f
C1701 vboost:141 top:738 0.00131062f
C1702 vboost:146 top:738 6.60245e-19
C1703 vboost:146 MM0:s 8.5192e-19
C1704 vboost:146 MM0@3:s 0.00108686f
C1705 vboost:156 top:16 2.68872e-19
C1706 vboost:156 top:731 3.7304e-19
C1707 vboost:166 top:16 4.55895e-19
C1708 vboost:166 top:738 6.87717e-19
C1709 vboost:166 top:1247 2.2213e-19
C1710 vboost:166 top:1807 8.61711e-19
C1711 vboost:172 top:872 8.39143e-19
C1712 vboost:176 top:731 0.00517393f
C1713 vboost:176 MM0@3:s 0.00237442f
C1714 vboost:208 top:716 0.00179814f
C1715 vboost:208 top:721 0.00157172f
C1716 vboost:208 top:738 4.3062e-19
C1717 vboost:213 top:721 0.00157172f
C1718 vboost:213 top:726 0.00157172f
C1719 vboost:213 top:738 4.3062e-19
C1720 vboost:218 top:731 0.00121845f
C1721 vboost:223 top:872 0.00120991f
C1722 vboost:252 top:872 0.00519106f
C1723 vboost:258 top:738 9.22659e-19
C1724 vboost:264 top:738 9.22659e-19
C1725 vboost:266 top:726 6.96764e-19
C1726 MM1@4:d MM1:s 0.0154144f
C1727 MM1@4:d MM1@3:s 0.0154144f
C1728 MM1@2:d MM1@3:s 0.0154144f
C1729 MM1@2:d MM0:s 0.0154144f
C1730 vboost:188 enable:64 2.46532e-19
C1731 vboost:190 enable:74 4.31636e-19
C1732 vboost:1 vddd_esd:65 0.00332656f
C1733 vboost:2 vddd_esd:65 0.00332656f
C1734 vboost:11 MM12<1>:g 0.0190047f
C1735 vboost:11 MM12<1>==2:g 0.0190047f
C1736 vboost:11 vddd_esd:65 0.00520476f
C1737 vboost:12 MM12<1>==3:g 0.0190047f
C1738 vboost:12 MM12<1>==4:g 0.0190047f
C1739 vboost:12 vddd_esd:65 0.00520476f
C1740 vboost:13 vddd_esd:65 0.00332656f
C1741 vboost:14 vddd_esd:65 0.00332656f
C1742 vboost:23 MM12<0>:g 0.0190047f
C1743 vboost:23 MM12<0>==2:g 0.0190047f
C1744 vboost:23 vddd_esd:65 0.00520476f
C1745 vboost:24 MM12<0>==3:g 0.0190047f
C1746 vboost:24 MM12<0>==4:g 0.0190047f
C1747 vboost:24 vddd_esd:65 0.00520476f
C1748 vboost:181 MM12<1>:g 6.42299e-19
C1749 vboost:181 MM12<1>==2:g 7.27724e-19
C1750 vboost:181 vddd_esd:76 0.00254415f
C1751 vboost:181 vddd_esd:82 6.28829e-19
C1752 vboost:185 MM12<0>:g 6.42299e-19
C1753 vboost:185 MM12<0>==2:g 7.27724e-19
C1754 vboost:185 vddd_esd:76 0.00254407f
C1755 vboost:185 vddd_esd 0.00854834f
C1756 vboost:185 vddd_esd:82 6.28829e-19
C1757 vboost:187 vddd_esd:76 0.00332955f
C1758 vboost:187 vddd_esd:82 0.00312083f
C1759 vboost:189 vddd_esd:76 0.00285167f
C1760 vboost:189 vddd_esd 0.0133026f
C1761 vboost:189 vddd_esd:82 0.00126192f
C1762 vboost:189 vddd_esd:91 0.00126192f
C1763 vboost:193 MM12<1>==3:g 7.27724e-19
C1764 vboost:193 MM12<1>==4:g 9.50371e-19
C1765 vboost:193 vddd_esd:76 0.00254415f
C1766 vboost:193 vddd_esd:91 6.28829e-19
C1767 vboost:197 MM12<0>==3:g 7.27724e-19
C1768 vboost:197 MM12<0>==4:g 0.00111543f
C1769 vboost:197 vddd_esd:76 0.00254405f
C1770 vboost:197 vddd_esd 0.00726081f
C1771 vboost:197 vddd_esd:91 6.28829e-19
C1772 vboost:199 vddd_esd:76 0.00128548f
C1773 vboost:199 vddd_esd:91 0.00120213f
C1774 vboost:205 vddd_esd:76 0.00128489f
C1775 vboost:205 vddd_esd:91 0.00120213f
C368_2 vboost:341 0 4.30969e-20
C369_2 vboost:339 0 4.30969e-20
C370_2 vboost:328 0 0.00993037f
C371_2 vboost:324 0 0.00484271f
C372_2 vboost:320 0 0.00411489f
C373_2 vboost:316 0 0.0037865f
C374_2 vboost:311 0 0.0101814f
C375_2 vboost:307 0 0.00391202f
C376_2 vboost:303 0 0.00411601f
C377_2 vboost:299 0 0.00372352f
C378_2 vboost:295 0 0.00372352f
C379_2 vboost:291 0 0.00382027f
C380_2 vboost:287 0 0.00426974f
C381_2 vboost:283 0 0.009083f
C382_2 vboost:281 0 7.09327e-19
C383_2 vboost:280 0 7.09327e-19
C384_2 vboost:278 0 0.017579f
C385_2 vboost:274 0 0.00270116f
C386_2 vboost:270 0 8.17455e-19
C387_2 vboost:266 0 0.00728117f
C388_2 vboost:264 0 0.00478951f
C389_2 vboost:260 0 0.00423338f
C390_2 vboost:258 0 0.00603432f
C391_2 vboost:255 0 0.00210613f
C392_2 vboost:254 0 0.0122915f
C393_2 vboost:253 0 0.00611435f
C394_2 vboost:252 0 0.0432938f
C395_2 vboost:251 0 0.0182894f
C396_2 vboost:247 0 0.0435791f
C397_2 vboost:242 0 0.271534f
C398_2 vboost:235 0 0.00654208f
C399_2 vboost:230 0 0.00694509f
C400_2 vboost:228 0 3.22837e-19
C401_2 vboost:227 0 1.1393e-19
C402_2 vboost:223 0 0.00214513f
C403_2 vboost:218 0 3.62567e-19
C404_2 vboost:213 0 0.00260754f
C405_2 vboost:208 0 0.0023264f
C406_2 vboost:205 0 0.0493704f
C407_2 vboost:199 0 0.0479314f
C408_2 vboost:197 0 0.002531f
C409_2 vboost:193 0 0.00236801f
C410_2 vboost:190 0 0.00133224f
C411_2 vboost:189 0 0.0072349f
C412_2 vboost:188 0 9.4366e-19
C413_2 vboost:187 0 0.00419434f
C414_2 vboost:185 0 0.00180009f
C415_2 vboost:181 0 0.00176811f
C416_2 vboost:178 0 6.38341e-19
C417_2 vboost:176 0 3.83992e-19
C418_2 vboost:172 0 0.00744977f
C419_2 vboost:166 0 0.00827553f
C420_2 vboost:160 0 0.0103514f
C421_2 vboost:156 0 0.0143127f
C422_2 vboost:146 0 0.00587446f
C423_2 vboost:141 0 0.00108436f
C424_2 vboost:135 0 0.00102479f
C425_2 vboost:109 0 0.0210219f
C426_2 vboost:80 0 0.00635577f
C427_2 vboost:79 0 0.00231572f
C428_2 vboost:78 0 0.0021962f
C429_2 vboost:77 0 0.00183415f
C430_2 vboost:52 0 0.00697595f
C431_2 vboost:51 0 0.00203649f
C432_2 vboost:50 0 0.00199298f
C433_2 vboost:49 0 0.00198186f
C434_2 vboost:48 0 0.00211482f
C435_2 vboost:47 0 0.00211482f
C436_2 vboost:46 0 0.00227096f
C437_2 vboost:45 0 0.00706427f
C438_2 vboost:24 0 1.29848e-20
C439_2 vboost:23 0 1.29848e-20
C440_2 vboost:14 0 3.60348e-19
C441_2 vboost:13 0 3.60348e-19
C442_2 vboost:12 0 1.04899e-20
C443_2 vboost:11 0 1.04899e-20
C444_2 vboost:2 0 3.60348e-19
C445_2 vboost:1 0 3.60348e-19
R446_4 vboost:341 vboost:347 4.5125
R447_4 vboost:340 vboost:347 4.5125
R448_4 vboost:339 vboost:343 4.5125
R449_4 vboost:338 vboost:343 4.5125
R450_4 vboost:276 vboost:278 0.440067
R451_4 vboost:272 vboost:274 0.284138
R452_3 vboost:268 vboost:270 0.775828
R453_3 vboost:267 vboost:281 0.0892672
R454_3 vboost:266 vboost:268 0.264036
R455_3 vboost:266 vboost:267 0.865329
R456_3 vboost:262 vboost:281 0.146902
R457_2 vboost:262 vboost:264 1.80933
R458_2 vboost:261 vboost:280 0.0892672
R459_2 vboost:260 vboost:281 0.0892672
R460_2 vboost:260 vboost:261 0.542445
R461_2 vboost:256 vboost:280 0.146902
R462_2 vboost:256 vboost:258 1.80933
R463_2 vboost:254 vboost:280 0.0892672
R464_2 vboost:254 vboost:255 1.25279
R465_2 vboost:252 vboost:272 0.236414
R466_2 vboost:252 vboost:253 2.9447
R467_2 vboost:249 vboost:255 0.236414
R468_2 vboost:249 vboost:251 3.20593
R469_2 vboost:248 vboost:278 0.239718
R470_2 vboost:248 vboost:251 0.78161
R471_2 vboost:245 vboost:278 0.239718
R472_2 vboost:245 vboost:247 1.97605
R473_2 vboost:244 vboost:253 0.236414
R474_2 vboost:244 vboost:247 2.46683
R475_2 vboost:240 vboost:276 0.0256918
R476_2 vboost:240 vboost:242 1.73698
R477_2 vboost:239 vboost:242 5.48271
R478_2 vboost:235 vboost:251 4
R479_2 vboost:235 vboost:237 0.172772
R480_2 vboost:230 vboost:247 4
R481_2 vboost:230 vboost:232 0.168133
R482_2 vboost:223 vboost:274 4.5
R483_2 vboost:218 vboost:270 2.25
R484_2 vboost:213 vboost:264 4.5
R485_2 vboost:208 vboost:258 4.5
R486_2 vboost:206 vboost:228 0.176721
R487_2 vboost:205 vboost:237 0.185694
R488_2 vboost:205 vboost:206 8.25125
R489_2 vboost:203 vboost:204 0.385556
R490_2 vboost:202 vboost:203 0.627004
R491_2 vboost:201 vboost:202 0.362477
R492_2 vboost:200 vboost:227 0.176721
R493_2 vboost:200 vboost:201 2.91031
R494_2 vboost:199 vboost:232 0.185694
R495_2 vboost:199 vboost:204 3.9323
R496_2 vboost:195 vboost:228 0.0459268
R497_2 vboost:195 vboost:197 1.04804
R498_2 vboost:191 vboost:227 0.0459268
R499_2 vboost:191 vboost:193 1.04804
R500_2 vboost:189 vboost:228 0.176721
R501_2 vboost:189 vboost:190 2.02954
R502_2 vboost:187 vboost:227 0.176721
R503_2 vboost:187 vboost:188 2.01738
R504_2 vboost:183 vboost:190 0.233181
R505_2 vboost:183 vboost:185 1.04804
R506_2 vboost:179 vboost:188 0.233181
R507_2 vboost:179 vboost:181 1.04804
R508_2 vboost:178 vboost:307 133.333
R509_2 vboost:173 vboost:174 0.189732
R510_2 vboost:172 vboost:311 133.333
R511_2 vboost:172 vboost:174 0.123438
R512_2 vboost:170 vboost:178 0.191782
R513_2 vboost:170 vboost:173 0.0462893
R514_2 vboost:167 vboost:168 0.189732
R515_2 vboost:166 vboost:328 133.333
R516_2 vboost:166 vboost:168 0.123438
R517_2 vboost:164 vboost:324 133.333
R518_2 vboost:164 vboost:167 0.123438
R519_2 vboost:162 vboost:176 0.113784
R520_2 vboost:162 vboost:164 0.108008
R521_2 vboost:160 vboost:223 4.5
R522_2 vboost:158 vboost:178 0.034167
R523_2 vboost:158 vboost:160 0.3256
R524_2 vboost:156 vboost:218 2.25
R525_2 vboost:154 vboost:176 0.115036
R526_2 vboost:154 vboost:156 0.14748
R527_2 vboost:152 vboost:153 0.189732
R528_2 vboost:151 vboost:320 133.333
R529_2 vboost:151 vboost:153 0.123438
R530_2 vboost:148 vboost:316 133.333
R531_2 vboost:148 vboost:152 0.123438
R532_2 vboost:146 vboost:176 0.113784
R533_2 vboost:146 vboost:151 0.108008
R534_2 vboost:144 vboost:213 4.5
R535_2 vboost:141 vboost:347 45
R536_2 vboost:141 vboost:144 0.426828
R537_2 vboost:138 vboost:208 4.5
R538_2 vboost:135 vboost:343 45
R539_2 vboost:135 vboost:138 0.426828
R540_2 vboost:131 vboost:132 0.189732
R541_2 vboost:130 vboost:303 133.333
R542_2 vboost:130 vboost:133 0.123438
R543_2 vboost:130 vboost:132 0.123438
R544_2 vboost:127 vboost:128 0.189732
R545_2 vboost:126 vboost:299 133.333
R546_2 vboost:126 vboost:131 0.123438
R547_2 vboost:126 vboost:128 0.123438
R548_2 vboost:123 vboost:124 0.189732
R549_2 vboost:122 vboost:295 133.333
R550_2 vboost:122 vboost:127 0.123438
R551_2 vboost:122 vboost:124 0.123438
R552_2 vboost:119 vboost:120 0.189732
R553_2 vboost:118 vboost:291 133.333
R554_2 vboost:118 vboost:123 0.123438
R555_2 vboost:118 vboost:120 0.123438
R556_2 vboost:115 vboost:116 0.189732
R557_2 vboost:114 vboost:287 133.333
R558_2 vboost:114 vboost:119 0.123438
R559_2 vboost:114 vboost:116 0.123438
R560_2 vboost:111 vboost:283 133.333
R561_2 vboost:111 vboost:115 0.123438
R562_2 vboost:109 vboost:178 0.191782
R563_2 vboost:109 vboost:133 0.0189732
R564_2 vboost:91 vboost:328 239.879
R565_2 vboost:88 vboost:324 239.879
R566_2 vboost:85 vboost:320 239.879
R567_2 vboost:82 vboost:316 239.879
R568_2 vboost:80 vboost:91 239.879
R569_2 vboost:79 vboost:88 239.879
R570_2 vboost:78 vboost:85 239.879
R571_2 vboost:77 vboost:82 239.879
R572_2 vboost:74 vboost:311 137.532
R573_2 vboost:71 vboost:307 137.532
R574_2 vboost:68 vboost:303 137.532
R575_2 vboost:65 vboost:299 137.532
R576_2 vboost:62 vboost:295 137.532
R577_2 vboost:59 vboost:291 137.532
R578_2 vboost:56 vboost:287 137.532
R579_2 vboost:53 vboost:283 137.532
R580_2 vboost:52 vboost:74 137.532
R581_2 vboost:51 vboost:71 137.532
R582_2 vboost:50 vboost:68 137.532
R583_2 vboost:49 vboost:65 137.532
R584_2 vboost:48 vboost:62 137.532
R585_2 vboost:47 vboost:59 137.532
R586_2 vboost:46 vboost:56 137.532
R587_2 vboost:45 vboost:53 137.532
R588_2 vboost:18 vboost:24 5.25938
R589_2 vboost:17 vboost:24 5.25938
R590_2 vboost:16 vboost:23 5.25938
R591_2 vboost:15 vboost:23 5.25938
R592_2 vboost:14 vboost:197 4.5
R593_2 vboost:14 vboost:24 26.6667
R594_2 vboost:13 vboost:185 4.5
R595_2 vboost:13 vboost:23 26.6667
R596_2 vboost:6 vboost:12 5.25938
R597_2 vboost:5 vboost:12 5.25938
R598_2 vboost:4 vboost:11 5.25938
R599_2 vboost:3 vboost:11 5.25938
R600_2 vboost:2 vboost:193 4.5
R601_2 vboost:2 vboost:12 26.6667
R602_2 vboost:1 vboost:181 4.5
R603_2 vboost:1 vboost:11 26.6667
** vboost 3.12782e-15 *
C1776 on:69 enableb:50 0.0218509f
C1777 on:79 enableb:21 0.0187581f
C1778 on:79 enableb:63 0.0163355f
C1779 on:79 enableb:77 0.00198413f
C1780 on:79 enableb:84 0.00441789f
C1781 on:125 enableb:84 0.021022f
C1782 MM8:g vssd:313 4.85236e-19
C1783 MM8@4:g vssd:313 4.85236e-19
C1784 MM8@3:g vssd:313 4.85236e-19
C1785 MM8@2:g vssd:140 3.91771e-19
C1786 MM8@2:g vssd:313 5.31272e-19
C1787 on:69 vssd:140 0.00136f
C1788 on:77 vssd:82 0.0589418f
C1789 on:79 vssd:70 0.00925745f
C1790 on:79 vssd:117 5.26903e-19
C1791 on:90 vssd:82 0.0100865f
C1792 on:125 vssd:70 0.0319456f
C1793 on:125 vssd:82 0.123664f
C1794 on:125 vssd:117 0.00185791f
C1795 on:125 vssd:189 0.00723706f
C1796 MM2:g vddd:261 7.29957e-19
C1797 MM2:g vddd:646 7.83387e-19
C1798 MM2:g MM2:s 0.0242774f
C1799 MM2@4:g vddd:265 3.80235e-19
C1800 MM2@4:g vddd:274 7.29957e-19
C1801 MM2@4:g vddd:646 7.83387e-19
C1802 MM2@4:g MM2@3:s 0.0242774f
C1803 MM2@3:g vddd:274 7.29957e-19
C1804 MM2@3:g vddd:646 7.83387e-19
C1805 MM2@3:g MM2@3:s 0.0242774f
C1806 MM2@2:g vddd:287 0.00111842f
C1807 MM2@2:g vddd:646 7.83387e-19
C1808 MM2@2:g vddd:1276 0.0242774f
C1809 on:50 vddd:265 2.16265e-19
C1810 on:50 vddd:274 0.00470647f
C1811 on:50 vddd:278 2.54731e-19
C1812 on:50 MM2:s 9.10404e-19
C1813 on:50 MM2@3:s 0.00358194f
C1814 on:50 vddd:1276 9.10404e-19
C1815 on:90 vddd:261 9.48224e-19
C1816 on:122 vddd:274 4.41593e-19
C1817 MM8:g net8:15 3.80487e-19
C1818 MM8:g net8:21 8.49601e-19
C1819 MM8:g MM8@4:d 0.0155342f
C1820 MM8@4:g net8:21 7.80501e-19
C1821 MM8@4:g net8:24 2.64853e-19
C1822 MM8@4:g MM8@4:d 0.0155342f
C1823 MM8@3:g net8:24 3.80487e-19
C1824 MM8@3:g net8:30 7.80501e-19
C1825 MM8@3:g MM8@2:d 0.0155342f
C1826 MM8@2:g net8:30 0.00182856f
C1827 MM8@2:g MM8@2:d 0.0155342f
C1828 on:69 net8:15 6.07548e-19
C1829 on:69 net8:21 0.00598542f
C1830 on:69 net8:24 7.76669e-19
C1831 on:69 net8:30 0.00598542f
C1832 on:69 MM8@4:d 0.00295123f
C1833 on:69 MM8@2:d 0.00295123f
C1834 on:79 net8:12 6.32961e-19
C1835 on:79 net8:15 0.00111023f
C1836 on:103 net8:21 4.73198e-19
C1837 on:119 net8:30 4.73198e-19
C1838 on:69 net13:119 2.52705e-19
C1839 on:77 net13:154 9.98746e-19
C1840 on:79 net13:149 5.967e-19
C1841 on:79 net13:165 2.92057e-19
C1842 on:79 net13:171 2.78371e-19
C1843 on:79 net13:180 0.00636978f
C1844 on:103 net13:180 2.48473e-19
C1845 on:125 net13:180 3.1152e-19
C1846 MM2:g net5:96 2.37041e-19
C1847 MM2:g MM2@4:d 0.0242774f
C1848 MM2@4:g net5:96 6.09932e-19
C1849 MM2@4:g MM2@4:d 0.0242774f
C1850 MM2@3:g net5:102 3.03603e-19
C1851 MM2@3:g MM2@2:d 0.0242774f
C1852 MM2@2:g net5:102 0.00100354f
C1853 MM2@2:g MM2@2:d 0.0242774f
C1854 on:50 net5:32 0.00748345f
C1855 on:50 net5:40 0.0072542f
C1856 on:50 net5:92 3.09816e-19
C1857 on:50 net5:96 0.00141302f
C1858 on:50 net5:98 4.00853e-19
C1859 on:50 net5:102 0.00138072f
C1860 on:50 MM2@4:d 0.00309982f
C1861 on:50 MM2@2:d 0.00306286f
C1862 on:79 net5:84 0.00400158f
C1863 on:90 net5:92 7.72174e-19
C1864 on:97 net5:32 6.08797e-19
C1865 on:97 net5:92 2.17804e-19
C1866 on:97 net5:96 0.00370156f
C1867 on:97 net5:98 8.88329e-19
C1868 on:103 net5:84 0.00132693f
C1869 on:111 net5:40 6.70184e-19
C1870 on:111 net5:102 0.00458167f
C1871 on:111 net5:104 4.32386e-19
C1872 MM8:g bot:1468 6.1371e-19
C1873 MM8:g MM8:s 0.0155342f
C1874 MM8@4:g bot:1468 5.90603e-19
C1875 MM8@4:g MM8@3:s 0.0155342f
C1876 MM8@3:g bot:1480 6.56789e-19
C1877 MM8@3:g MM8@3:s 0.0155342f
C1878 MM8@2:g bot:1480 6.33237e-19
C1879 MM8@2:g bot:2139 0.0155342f
C1880 on:69 bot:811 0.00472019f
C1881 on:69 bot:1468 3.13723e-19
C1882 on:69 bot:1480 3.13723e-19
C1883 on:69 bot:1831 7.10558e-19
C1884 on:69 MM8:s 6.23301e-19
C1885 on:69 MM8@3:s 0.00273613f
C1886 on:69 bot:2139 6.70913e-19
C1887 on:79 bot:799 4.14676e-19
C1888 on:79 bot:1466 0.00269301f
C1889 on:79 bot:1468 5.55881e-19
C1890 on:79 bot:1831 6.32521e-19
C1891 on:103 bot:1468 0.0017727f
C1892 on:119 bot:811 3.17512e-19
C1893 on:119 bot:1480 0.00170759f
C1894 on:119 bot:1831 7.90329e-19
C1895 on:123 bot:811 2.52625e-19
C1896 on:123 bot:1478 0.00439835f
C1897 MM2:g MM9:g 2.16197e-19
C1898 MM2:g MM9@2:g 0.00187048f
C1899 on:50 enable:50 0.0141054f
C1900 on:50 enable:74 6.00134e-19
C1901 on:50 enable:111 7.78607e-19
C1902 on:69 enable:37 0.00451674f
C1903 on:69 enable:98 2.36715e-19
C1904 on:77 enable:58 0.016801f
C1905 on:77 enable:81 5.53172e-19
C1906 on:79 enable:37 0.00487903f
C1907 on:79 enable:64 0.0678195f
C1908 on:79 enable:81 0.00325465f
C1909 on:90 enable:50 0.0026897f
C1910 on:90 enable:74 0.04127f
C1911 on:90 enable:81 0.00266374f
C1912 on:97 enable:50 5.40806e-19
C1913 on:97 enable:74 0.00523372f
C1914 on:103 enable:37 2.82921e-19
C1915 on:103 enable:64 0.00146965f
C1916 on:125 enable:58 0.0114941f
C1917 on:125 enable:64 0.00147644f
C1918 on:125 enable:74 0.00147633f
C1919 on:125 enable:81 0.197648f
C1920 on:135 enable:37 2.8504e-19
C1921 on:135 enable:98 9.5715e-19
C1922 on:152 enable:50 7.55975e-19
C1923 on:152 enable:107 2.95506e-19
C1924 on:152 enable:111 0.00838087f
C1925 MM8@4:g MM12<1>==3:g 2.39669e-19
C1926 MM8@2:g MM12<1>==4:g 2.39669e-19
C1927 MM2:g vddd_esd 0.00356385f
C1928 MM2@4:g vddd_esd 0.00456707f
C1929 on:50 vddd_esd 0.00390339f
C1930 on:90 vddd_esd 0.0126453f
C1931 on:97 vddd_esd 0.00850026f
C1932 on:108 vddd_esd 0.00574507f
C1933 on:125 vddd_esd 0.00284157f
C1934 on:152 vddd_esd 8.78324e-19
C1935 on:156 vddd_esd 6.72515e-19
C1936 on:69 charge:64 0.00174431f
C1937 on:79 charge:64 4.8482e-19
C1938 on:79 charge:81 0.0428099f
C1939 on:119 charge:81 0.0020592f
C1940 on:125 charge:81 0.0010673f
C1941 on:135 charge:105 0.00155212f
C1942 on:139 charge:109 0.00155212f
C1943 on:143 charge:113 0.00150382f
C1944 on:147 charge:117 0.00152734f
C1945 on:79 vboost:187 7.96172e-19
C1946 on:97 vboost:189 2.40921e-19
C1947 on:111 vboost:228 2.40921e-19
C172_2 on:164 0 0.00959218f
C173_2 on:160 0 0.00458074f
C174_2 on:156 0 0.00369423f
C175_2 on:152 0 0.0037661f
C176_2 on:147 0 0.00888138f
C177_2 on:143 0 0.00377202f
C178_2 on:139 0 0.00363799f
C179_2 on:135 0 0.00819822f
C180_2 on:125 0 0.0475573f
C181_2 on:123 0 1.34891e-19
C182_2 on:122 0 2.89274e-19
C183_2 on:119 0 0.00348875f
C184_2 on:116 0 6.44478e-19
C185_2 on:111 0 0.00561787f
C186_2 on:108 0 0.00661996f
C187_2 on:103 0 0.00244477f
C188_2 on:97 0 0.00161405f
C189_2 on:90 0 0.0526305f
C190_2 on:79 0 0.0163454f
C191_2 on:77 0 0.0190805f
C192_2 on:69 0 0.013946f
C193_2 on:50 0 0.0180691f
C194_2 on:20 0 0.00632729f
C195_2 on:19 0 0.00192763f
C196_2 on:18 0 0.00226615f
C197_2 on:17 0 0.00144981f
C198_2 on:4 0 0.00802066f
C199_2 on:3 0 0.00266741f
C200_2 on:2 0 0.00251513f
C201_2 on:1 0 0.0083232f
R202_3 on:131 on:132 0.541672
R203_3 on:128 on:132 6.28695
R204_2 on:128 on:129 5.09404
R205_2 on:125 on:129 0.208336
R206_2 on:119 on:120 0.239226
R207_2 on:117 on:123 0.151187
R208 on:117 on:120 0.0167386
R209 on:116 on:123 0.0687764
R210 on:115 on:116 0.182991
R211 on:111 on:112 0.0332712
R212 on:109 on:122 0.176721
R213 on:109 on:112 0.266169
R214 on:107 on:122 0.0459268
R215 on:107 on:108 0.648787
R216 on:103 on:123 0.151187
R217 on:103 on:105 0.270936
R218 on:97 on:122 0.176721
R219 on:97 on:99 0.230346
R220 on:95 on:96 0.266169
R221 on:94 on:95 3.46442
R222 on:92 on:131 8
R223 on:92 on:94 0.415889
R224 on:90 on:108 0.233181
R225 on:90 on:96 0.608772
R226 on:88 on:89 0.0499067
R227 on:87 on:88 0.164533
R228 on:86 on:87 0.881686
R229 on:85 on:86 2.31874
R230 on:84 on:85 1.5752
R231 on:83 on:84 0.289843
R232 on:81 on:125 8
R233 on:81 on:83 0.415889
R234 on:79 on:115 0.233181
R235 on:79 on:89 0.665226
R236 on:77 on:128 8
R237 on:73 on:77 2.86132
R238 on:70 on:71 0.189732
R239 on:69 on:147 133.333
R240 on:69 on:71 0.123683
R241 on:67 on:119 4.5
R242 on:67 on:70 0.0154604
R243 on:64 on:65 0.189732
R244 on:63 on:143 133.333
R245 on:63 on:67 0.108223
R246 on:63 on:65 0.123683
R247 on:60 on:139 133.333
R248 on:60 on:64 0.123683
R249 on:60 on:61 0.123683
R250 on:57 on:105 4.5
R251 on:57 on:61 0.0189732
R252 on:57 on:58 0.170759
R253 on:54 on:135 133.333
R254 on:54 on:58 0.123683
R255 on:50 on:164 133.333
R256 on:50 on:51 0.123438
R257 on:47 on:111 4.5
R258 on:47 on:51 0.151786
R259 on:47 on:48 0.0379465
R260 on:44 on:45 0.189732
R261 on:43 on:160 133.333
R262 on:43 on:48 0.123438
R263 on:43 on:45 0.123438
R264 on:41 on:156 133.333
R265 on:41 on:44 0.123438
R266_2 on:38 on:39 0.189732
R267_2 on:37 on:99 4.5
R268_3 on:37 on:41 0.0925786
R269_3 on:37 on:39 0.0308595
R270_3 on:34 on:152 133.333
R271_3 on:34 on:38 0.123438
R272_3 on:31 on:164 239.879
R273_3 on:28 on:160 239.879
R274_3 on:25 on:156 239.879
R275_3 on:22 on:152 239.879
R276_3 on:20 on:31 479.758
R277_3 on:19 on:28 479.758
R278_3 on:18 on:25 479.758
R279_3 on:17 on:22 479.758
R280_3 on:14 on:147 137.532
R281_3 on:11 on:143 137.532
R282_3 on:8 on:139 137.532
R283_3 on:5 on:135 137.532
R284_3 on:4 on:14 137.532
R285_3 on:3 on:11 137.532
R286_3 on:2 on:8 137.532
R287_3 on:1 on:5 137.532
** on 1.53538e-15 *
XXI0/MM2 XI0/MM2:d XI0/MM2:g XI0/MM2:s MM14:b nch_mac L=3e-08 W=2.2e-07
+ AD=1.65e-14 AS=1.65e-14 PD=5.9e-07 PS=5.9e-07 NRD=1.30437 NRS=1.30437
+ sa=7.5e-08 sb=7.5e-08 sca=11.645 scb=0.0138628 scc=0.000802883 sa1=7.5e-08
+ sb1=7.5e-08 sa2=7.5e-08 sb2=7.5e-08 sa3=7.5e-08 sb3=7.5e-08 dfm_flag=1
+ spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=9.19776e-08 sa4=7.5e-08
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.14444e-07 enx=2.43645e-06
+ enx1=2.22429e-06 eny=4.94184e-06 eny1=4.94116e-06 eny2=4.94183e-06
+ rex=2.40411e-06 rey=2.31597e-06 sodxa=5.6e-07 sodxb=2.1e-07 sodx=3.23109e-07
+ sodx1=2.23682e-07 sodx2=9.32199e-07 sodx4=9.35725e-08 sa5=7.5e-08 sa6=7.5e-08
+ sa7=7.5e-08 sody=7.25357e-07 dw1=-1.22088e-20 dw=0 dvt_dfm=0 spmt=1.11111e+15
+ spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0 spomb1=1.11111e+60
+ _ccoflag=0 _rcoflag=0 _rgflag=0
XMM13 MM13:d MM13:g MM13:s MM14:b nch_mac L=3e-08 W=2.2e-07 AD=1.1e-14
+ AS=1.1e-14 PD=3.2e-07 PS=3.2e-07 NRD=2.26737 NRS=2.26737 sa=2.05e-07
+ sb=1.115e-06 sca=1.53854 scb=2.62315e-05 scc=8.35423e-10 sa1=2.05e-07
+ sb1=1.115e-06 sa2=2.05e-07 sb2=1.115e-06 sa3=2.05e-07 sb3=1.115e-06 dfm_flag=1
+ spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.52655e-07 sa4=3.46853e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.67345e-07 enx=2.83743e-06
+ enx1=2.66886e-06 eny=4.47242e-06 eny1=4.42335e-06 eny2=4.4721e-06
+ rex=2.48236e-06 rey=2.50533e-06 sodxa=8.2e-07 sodxb=1.265e-06 sodx=1.00661e-06
+ sodx1=6.08007e-07 sodx2=1.29201e-06 sodx4=3.05602e-07 sa5=3.91524e-07
+ sa6=5.05195e-07 sa7=2.5803e-07 sody=3.64819e-07 dw1=-1.22088e-20 dw=0
+ dvt_dfm=0 spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM7 MM7:d MM7:g MM7:s MM14:b nch_mac L=3e-08 W=2.2e-07 AD=1.1e-14 AS=1.65e-14
+ PD=3.2e-07 PS=5.9e-07 NRD=2.26737 NRS=1.30437 sa=7.5e-08 sb=2.05e-07
+ sca=11.4812 scb=0.01386 scc=0.000802883 sa1=7.5e-08 sb1=2.05e-07 sa2=7.5e-08
+ sb2=2.05e-07 sa3=7.5e-08 sb3=2.05e-07 dfm_flag=1 spa=1e-07 spa1=1e-07
+ spa2=1e-07 spa3=1e-07 sap=1.04359e-07 sa4=1.10059e-07 spba=1.15715e-07
+ spba1=1.17043e-07 sapb=1.25813e-07 enx=2.83743e-06 enx1=2.66886e-06
+ eny=4.94184e-06 eny1=4.94116e-06 eny2=4.94183e-06 rex=2.48236e-06
+ rey=2.31597e-06 sodxa=2.1e-07 sodxb=2.1e-07 sodx=2.1e-07 sodx1=2.25894e-07
+ sodx2=8.83716e-07 sodx4=1.05762e-07 sa5=1.23175e-07 sa6=1.63865e-07
+ sa7=9.32253e-08 sody=3.9632e-07 dw1=-1.22088e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM13@4 MM13@4:d MM13@4:g MM13@4:s MM14:b nch_mac L=3e-08 W=2.2e-07 AD=1.1e-14
+ AS=1.1e-14 PD=3.2e-07 PS=3.2e-07 NRD=2.26737 NRS=2.26737 sa=3.35e-07
+ sb=9.85e-07 sca=1.51948 scb=2.61607e-05 scc=8.35416e-10 sa1=3.35e-07
+ sb1=9.85e-07 sa2=3.35e-07 sb2=9.85e-07 sa3=3.35e-07 sb3=9.85e-07 dfm_flag=1
+ spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.72416e-07 sa4=5.00231e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.83343e-07 enx=2.96043e-06
+ enx1=2.80597e-06 eny=4.47242e-06 eny1=4.42335e-06 eny2=4.4721e-06
+ rex=2.50097e-06 rey=2.50533e-06 sodxa=8.2e-07 sodxb=1.265e-06 sodx=1.00661e-06
+ sodx1=7.1811e-07 sodx2=1.34259e-06 sodx4=4.61243e-07 sa5=5.23022e-07
+ sa6=5.47563e-07 sa7=4.16916e-07 sody=3.64819e-07 dw1=-1.22088e-20 dw=0
+ dvt_dfm=0 spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM7@2 MM7@2:d MM7@2:g MM7@2:s MM14:b nch_mac L=3e-08 W=2.2e-07 AD=1.1e-14
+ AS=1.65e-14 PD=3.2e-07 PS=5.9e-07 NRD=2.26737 NRS=1.30437 sa=2.05e-07
+ sb=7.5e-08 sca=11.4622 scb=0.0138599 scc=0.000802883 sa1=2.05e-07 sb1=7.5e-08
+ sa2=2.05e-07 sb2=7.5e-08 sa3=2.05e-07 sb3=7.5e-08 dfm_flag=1 spa=1e-07
+ spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.04359e-07 sa4=1.10059e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.25813e-07 enx=2.96043e-06
+ enx1=2.80597e-06 eny=4.94184e-06 eny1=4.94116e-06 eny2=4.94183e-06
+ rex=2.50097e-06 rey=2.31597e-06 sodxa=2.1e-07 sodxb=2.1e-07 sodx=2.1e-07
+ sodx1=2.25894e-07 sodx2=8.83716e-07 sodx4=1.05762e-07 sa5=1.23175e-07
+ sa6=1.63865e-07 sa7=9.32253e-08 sody=3.9632e-07 dw1=-1.22088e-20 dw=0
+ dvt_dfm=0 spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM13@3 MM13@3:d MM13@3:g MM13@3:s MM14:b nch_mac L=3e-08 W=2.2e-07 AD=1.1e-14
+ AS=1.1e-14 PD=3.2e-07 PS=3.2e-07 NRD=2.26737 NRS=2.26737 sa=4.65e-07
+ sb=8.55e-07 sca=1.51431 scb=2.61465e-05 scc=8.35416e-10 sa1=4.65e-07
+ sb1=8.55e-07 sa2=4.65e-07 sb2=8.55e-07 sa3=4.65e-07 sb3=8.55e-07 dfm_flag=1
+ spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.8342e-07 sa4=6.02483e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.92051e-07 enx=3.07885e-06
+ enx1=2.93804e-06 eny=4.47242e-06 eny1=4.42335e-06 eny2=4.4721e-06
+ rex=2.51665e-06 rey=2.50533e-06 sodxa=8.2e-07 sodxb=1.265e-06 sodx=1.00661e-06
+ sodx1=7.92075e-07 sodx2=1.42346e-06 sodx4=5.9482e-07 sa5=6.10688e-07
+ sa6=6.08431e-07 sa7=5.57582e-07 sody=4.32229e-07 dw1=-1.22088e-20 dw=0
+ dvt_dfm=0 spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM13@2 MM13@2:d MM13@2:g MM13@2:s MM14:b nch_mac L=3e-08 W=2.2e-07 AD=1.1e-14
+ AS=1.1e-14 PD=3.2e-07 PS=3.2e-07 NRD=2.26737 NRS=2.26737 sa=5.95e-07
+ sb=7.25e-07 sca=1.52261 scb=2.61702e-05 scc=8.35417e-10 sa1=5.95e-07
+ sb1=7.25e-07 sa2=5.95e-07 sb2=7.25e-07 sa3=5.95e-07 sb3=7.25e-07 dfm_flag=1
+ spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.88459e-07 sa4=6.53609e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.95994e-07 enx=3.19304e-06
+ enx1=3.06535e-06 eny=4.47242e-06 eny1=4.42335e-06 eny2=4.4721e-06
+ rex=2.52972e-06 rey=2.50533e-06 sodxa=8.2e-07 sodxb=1.265e-06 sodx=1.00661e-06
+ sodx1=8.33702e-07 sodx2=1.49542e-06 sodx4=6.84544e-07 sa5=6.54521e-07
+ sa6=6.53505e-07 sa7=6.474e-07 sody=4.32229e-07 dw1=-1.22088e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM5 MM5:d MM5:g MM5:s MM14:b nch_mac L=3e-08 W=2.2e-07 AD=1.1e-14 AS=1.1e-14
+ PD=3.2e-07 PS=3.2e-07 NRD=2.26737 NRS=2.26737 sa=7.25e-07 sb=5.95e-07
+ sca=1.54505 scb=2.62633e-05 scc=8.35428e-10 sa1=7.25e-07 sb1=5.95e-07
+ sa2=7.25e-07 sb2=5.95e-07 sa3=7.25e-07 sb3=5.95e-07 dfm_flag=1 spa=1e-07
+ spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.88459e-07 sa4=6.53609e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.95994e-07 enx=3.30332e-06
+ enx1=3.18816e-06 eny=4.47242e-06 eny1=4.42335e-06 eny2=4.4721e-06
+ rex=2.54045e-06 rey=2.50533e-06 sodxa=8.2e-07 sodxb=1.265e-06 sodx=1.00661e-06
+ sodx1=8.4388e-07 sodx2=1.51369e-06 sodx4=6.968e-07 sa5=6.54521e-07
+ sa6=6.53505e-07 sa7=6.474e-07 sody=3.64819e-07 dw1=-1.22088e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM8 MM8:d MM8:g MM8:s MM14:b nch_mac L=3e-08 W=2.2e-07 AD=1.1e-14 AS=1.65e-14
+ PD=3.2e-07 PS=5.9e-07 NRD=2.26737 NRS=1.30437 sa=7.5e-08 sb=4.65e-07
+ sca=11.4877 scb=0.01386 scc=0.000802883 sa1=7.5e-08 sb1=4.65e-07 sa2=7.5e-08
+ sb2=4.65e-07 sa3=7.5e-08 sb3=4.65e-07 dfm_flag=1 spa=1e-07 spa1=1e-07
+ spa2=1e-07 spa3=1e-07 sap=1.10187e-07 sa4=1.29744e-07 spba=1.15715e-07
+ spba1=1.17043e-07 sapb=1.31047e-07 enx=3.30332e-06 enx1=3.18816e-06
+ eny=4.94184e-06 eny1=4.94116e-06 eny2=4.94183e-06 rex=2.54045e-06
+ rey=2.31597e-06 sodxa=2.1e-07 sodxb=1.395e-06 sodx=4.36019e-07
+ sodx1=2.84284e-07 sodx2=1.00843e-06 sodx4=1.07205e-07 sa5=1.70226e-07
+ sa6=3.33607e-07 sa7=9.46441e-08 sody=3.9632e-07 dw1=-1.22088e-20 dw=0
+ dvt_dfm=0 spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM5@4 MM5@4:d MM5@4:g MM5@4:s MM14:b nch_mac L=3e-08 W=2.2e-07 AD=1.1e-14
+ AS=1.1e-14 PD=3.2e-07 PS=3.2e-07 NRD=2.26737 NRS=2.26737 sa=8.55e-07
+ sb=4.65e-07 sca=1.58348 scb=2.65479e-05 scc=8.35538e-10 sa1=8.55e-07
+ sb1=4.65e-07 sa2=8.55e-07 sb2=4.65e-07 sa3=8.55e-07 sb3=4.65e-07 dfm_flag=1
+ spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.8342e-07 sa4=6.02483e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.92051e-07 enx=3.40996e-06
+ enx1=3.30669e-06 eny=4.47242e-06 eny1=4.42335e-06 eny2=4.4721e-06
+ rex=2.54904e-06 rey=2.50533e-06 sodxa=8.2e-07 sodxb=1.265e-06 sodx=1.00661e-06
+ sodx1=8.21446e-07 sodx2=1.47032e-06 sodx4=6.21972e-07 sa5=6.10688e-07
+ sa6=6.08431e-07 sa7=5.57582e-07 sody=3.64819e-07 dw1=-1.22088e-20 dw=0
+ dvt_dfm=0 spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM8@4 MM8@4:d MM8@4:g MM8@4:s MM14:b nch_mac L=3e-08 W=2.2e-07 AD=1.1e-14
+ AS=1.1e-14 PD=3.2e-07 PS=3.2e-07 NRD=2.26737 NRS=2.26737 sa=2.05e-07
+ sb=3.35e-07 sca=11.5262 scb=0.0138603 scc=0.000802883 sa1=2.05e-07
+ sb1=3.35e-07 sa2=2.05e-07 sb2=3.35e-07 sa3=2.05e-07 sb3=3.35e-07 dfm_flag=1
+ spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.37725e-07 sa4=2.54416e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.54913e-07 enx=3.40996e-06
+ enx1=3.30669e-06 eny=4.94184e-06 eny1=4.94116e-06 eny2=4.94183e-06
+ rex=2.54904e-06 rey=2.31597e-06 sodxa=2.1e-07 sodxb=1.395e-06 sodx=4.36019e-07
+ sodx1=3.72388e-07 sodx2=1.00269e-06 sodx4=2.45831e-07 sa5=2.58914e-07
+ sa6=2.79332e-07 sa7=2.41218e-07 sody=3.9632e-07 dw1=-1.22088e-20 dw=0
+ dvt_dfm=0 spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM5@3 MM5@3:d MM5@3:g MM5@3:s MM14:b nch_mac L=3e-08 W=2.2e-07 AD=1.1e-14
+ AS=1.1e-14 PD=3.2e-07 PS=3.2e-07 NRD=2.26737 NRS=2.26737 sa=9.85e-07
+ sb=3.35e-07 sca=1.64127 scb=2.73934e-05 scc=8.36591e-10 sa1=9.85e-07
+ sb1=3.35e-07 sa2=9.85e-07 sb2=3.35e-07 sa3=9.85e-07 sb3=3.35e-07 dfm_flag=1
+ spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.72416e-07 sa4=5.00231e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.83343e-07 enx=3.51322e-06
+ enx1=3.42116e-06 eny=4.47242e-06 eny1=4.42335e-06 eny2=4.4721e-06
+ rex=2.55565e-06 rey=2.50533e-06 sodxa=8.2e-07 sodxb=1.265e-06 sodx=1.00661e-06
+ sodx1=7.63057e-07 sodx2=1.40407e-06 sodx4=4.88387e-07 sa5=5.23022e-07
+ sa6=5.47563e-07 sa7=4.16916e-07 sody=3.64819e-07 dw1=-1.22088e-20 dw=0
+ dvt_dfm=0 spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM8@3 MM8@3:d MM8@3:g MM8@3:s MM14:b nch_mac L=3e-08 W=2.2e-07 AD=1.1e-14
+ AS=1.1e-14 PD=3.2e-07 PS=3.2e-07 NRD=2.26737 NRS=2.26737 sa=3.35e-07
+ sb=2.05e-07 sca=11.584 scb=0.0138612 scc=0.000802883 sa1=3.35e-07 sb1=2.05e-07
+ sa2=3.35e-07 sb2=2.05e-07 sa3=3.35e-07 sb3=2.05e-07 dfm_flag=1 spa=1e-07
+ spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.37725e-07 sa4=2.54416e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.54913e-07 enx=3.51322e-06
+ enx1=3.42116e-06 eny=4.94184e-06 eny1=4.94116e-06 eny2=4.94183e-06
+ rex=2.55565e-06 rey=2.31597e-06 sodxa=2.1e-07 sodxb=1.395e-06 sodx=4.36019e-07
+ sodx1=4.11742e-07 sodx2=1.02581e-06 sodx4=2.88981e-07 sa5=2.58914e-07
+ sa6=2.79332e-07 sa7=2.41218e-07 sody=3.9632e-07 dw1=-1.22088e-20 dw=0
+ dvt_dfm=0 spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM5@2 MM5@2:d MM5@2:g MM5@2:s MM14:b nch_mac L=3e-08 W=2.2e-07 AD=1.1e-14
+ AS=1.1e-14 PD=3.2e-07 PS=3.2e-07 NRD=2.26737 NRS=2.26737 sa=1.115e-06
+ sb=2.05e-07 sca=1.72399 scb=2.98801e-05 scc=8.46594e-10 sa1=1.115e-06
+ sb1=2.05e-07 sa2=1.115e-06 sb2=2.05e-07 sa3=1.115e-06 sb3=2.05e-07 dfm_flag=1
+ spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.52655e-07 sa4=3.46853e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.67345e-07 enx=3.61332e-06
+ enx1=3.53179e-06 eny=4.47242e-06 eny1=4.42335e-06 eny2=4.4721e-06
+ rex=2.56037e-06 rey=2.50533e-06 sodxa=8.2e-07 sodxb=1.265e-06 sodx=1.00661e-06
+ sodx1=6.61981e-07 sodx2=1.35967e-06 sodx4=3.24873e-07 sa5=3.91524e-07
+ sa6=5.05195e-07 sa7=2.5803e-07 sody=3.64819e-07 dw1=-1.22088e-20 dw=0
+ dvt_dfm=0 spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM8@2 MM8@2:d MM8@2:g MM8@2:s MM14:b nch_mac L=3e-08 W=2.2e-07 AD=1.1e-14
+ AS=1.65e-14 PD=3.2e-07 PS=5.9e-07 NRD=2.26737 NRS=1.30437 sa=4.65e-07
+ sb=7.5e-08 sca=11.6667 scb=0.0138637 scc=0.000802883 sa1=4.65e-07 sb1=7.5e-08
+ sa2=4.65e-07 sb2=7.5e-08 sa3=4.65e-07 sb3=7.5e-08 dfm_flag=1 spa=1e-07
+ spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.10187e-07 sa4=1.29744e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.31047e-07 enx=3.61332e-06
+ enx1=3.53179e-06 eny=4.94184e-06 eny1=4.94116e-06 eny2=4.94183e-06
+ rex=2.56037e-06 rey=2.31597e-06 sodxa=2.1e-07 sodxb=1.395e-06 sodx=4.36019e-07
+ sodx1=3.86082e-07 sodx2=1.07888e-06 sodx4=1.40126e-07 sa5=1.70226e-07
+ sa6=3.33607e-07 sa7=9.46441e-08 sody=3.9632e-07 dw1=-1.22088e-20 dw=0
+ dvt_dfm=0 spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM11 MM11:d MM11:g MM11:s Mncap<1>:b nch_mac L=3e-08 W=2.2e-07 AD=1.1e-14
+ AS=1.65e-14 PD=3.2e-07 PS=5.9e-07 NRD=2.26737 NRS=1.30437 sa=7.5e-08
+ sb=9.85e-07 sca=1.50331 scb=1.64808e-05 scc=1.82263e-10 sa1=7.5e-08
+ sb1=9.85e-07 sa2=7.5e-08 sb2=9.85e-07 sa3=7.5e-08 sb3=9.85e-07 dfm_flag=1
+ spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.13048e-07 sa4=1.40204e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.33591e-07 enx=5e-06 enx1=5e-06
+ eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.26961e-06 rey=2.26961e-06
+ sodxa=1.235e-06 sodxb=5.9e-07 sodx=8.25147e-07 sodx1=4.79541e-07
+ sodx2=1.31202e-06 sodx4=1.38122e-07 sa5=2.07084e-07 sa6=4.75107e-07
+ sa7=9.47682e-08 sody=5.22695e-07 dw1=-1.22088e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM11@4 MM11@4:d MM11@4:g MM11@4:s Mncap<1>:b nch_mac L=3e-08 W=2.2e-07
+ AD=1.1e-14 AS=1.1e-14 PD=3.2e-07 PS=3.2e-07 NRD=2.26737 NRS=2.26737
+ sa=2.05e-07 sb=8.55e-07 sca=1.36304 scb=7.22342e-06 scc=2.4445e-11
+ sa1=2.05e-07 sb1=8.55e-07 sa2=2.05e-07 sb2=8.55e-07 sa3=2.05e-07 sb3=8.55e-07
+ dfm_flag=1 spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.50319e-07
+ sa4=3.31124e-07 spba=1.15715e-07 spba1=1.17043e-07 sapb=1.65421e-07 enx=5e-06
+ enx1=5e-06 eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.26961e-06 rey=2.26961e-06
+ sodxa=1.235e-06 sodxb=5.9e-07 sodx=8.25147e-07 sodx1=6.10366e-07
+ sodx2=1.30487e-06 sodx4=3.22634e-07 sa5=3.65247e-07 sa6=4.75614e-07
+ sa7=2.57376e-07 sody=5.22695e-07 dw1=-1.22088e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM11@3 MM11@3:d MM11@3:g MM11@3:s Mncap<1>:b nch_mac L=3e-08 W=2.2e-07
+ AD=1.1e-14 AS=1.1e-14 PD=3.2e-07 PS=3.2e-07 NRD=2.26737 NRS=2.26737
+ sa=3.35e-07 sb=7.25e-07 sca=1.2573 scb=4.03788e-06 scc=7.64873e-12
+ sa1=3.35e-07 sb1=7.25e-07 sa2=3.35e-07 sb2=7.25e-07 sa3=3.35e-07 sb3=7.25e-07
+ dfm_flag=1 spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.67481e-07
+ sa4=4.58405e-07 spba=1.15715e-07 spba1=1.17043e-07 sapb=1.79393e-07 enx=5e-06
+ enx1=5e-06 eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.26961e-06 rey=2.26961e-06
+ sodxa=1.235e-06 sodxb=5.9e-07 sodx=8.25147e-07 sodx1=6.79054e-07
+ sodx2=1.31545e-06 sodx4=4.7489e-07 sa5=4.70689e-07 sa6=4.98953e-07
+ sa7=4.09222e-07 sody=5.22695e-07 dw1=-1.22088e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM11@2 MM11@2:d MM11@2:g MM11@2:s Mncap<1>:b nch_mac L=3e-08 W=2.2e-07
+ AD=1.1e-14 AS=1.1e-14 PD=3.2e-07 PS=3.2e-07 NRD=2.26737 NRS=2.26737
+ sa=4.65e-07 sb=5.95e-07 sca=1.17563 scb=2.95225e-06 scc=5.87723e-12
+ sa1=4.65e-07 sb1=5.95e-07 sa2=4.65e-07 sb2=5.95e-07 sa3=4.65e-07 sb3=5.95e-07
+ dfm_flag=1 spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.74881e-07
+ sa4=5.22045e-07 spba=1.15715e-07 spba1=1.17043e-07 sapb=1.85305e-07 enx=5e-06
+ enx1=5e-06 eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.26961e-06 rey=2.26961e-06
+ sodxa=1.235e-06 sodxb=5.9e-07 sodx=8.25147e-07 sodx1=7.01269e-07
+ sodx2=1.32202e-06 sodx4=5.61978e-07 sa5=5.2341e-07 sa6=5.25653e-07
+ sa7=5.14436e-07 sody=5.22695e-07 dw1=-1.22088e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM10 MM10:d MM10:g MM10:s Mncap<1>:b nch_mac L=3e-08 W=2.2e-07 AD=1.1e-14
+ AS=1.1e-14 PD=3.2e-07 PS=3.2e-07 NRD=2.26737 NRS=2.26737 sa=5.95e-07
+ sb=4.65e-07 sca=1.11124 scb=2.58522e-06 scc=5.6918e-12 sa1=5.95e-07
+ sb1=4.65e-07 sa2=5.95e-07 sb2=4.65e-07 sa3=5.95e-07 sb3=4.65e-07 dfm_flag=1
+ spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.74881e-07 sa4=5.22045e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.85305e-07 enx=5e-06 enx1=5e-06
+ eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.26961e-06 rey=2.26961e-06
+ sodxa=1.235e-06 sodxb=5.9e-07 sodx=8.25147e-07 sodx1=6.84169e-07
+ sodx2=1.29632e-06 sodx4=5.4162e-07 sa5=5.2341e-07 sa6=5.25653e-07
+ sa7=5.14436e-07 sody=5.22695e-07 dw1=-1.22088e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM10@4 MM10@4:d MM10@4:g MM10@4:s Mncap<1>:b nch_mac L=3e-08 W=2.2e-07
+ AD=1.1e-14 AS=1.1e-14 PD=3.2e-07 PS=3.2e-07 NRD=2.26737 NRS=2.26737
+ sa=7.25e-07 sb=3.35e-07 sca=1.05958 scb=2.46197e-06 scc=5.67251e-12
+ sa1=7.25e-07 sb1=3.35e-07 sa2=7.25e-07 sb2=3.35e-07 sa3=7.25e-07 sb3=3.35e-07
+ dfm_flag=1 spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.67481e-07
+ sa4=4.58405e-07 spba=1.15715e-07 spba1=1.17043e-07 sapb=1.79393e-07 enx=5e-06
+ enx1=5e-06 eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.26961e-06 rey=2.26961e-06
+ sodxa=1.235e-06 sodxb=5.9e-07 sodx=8.25147e-07 sodx1=6.30535e-07
+ sodx2=1.24897e-06 sodx4=4.35686e-07 sa5=4.70689e-07 sa6=4.98953e-07
+ sa7=4.09222e-07 sody=5.22695e-07 dw1=-1.22088e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM10@3 MM10@3:d MM10@3:g MM10@3:s Mncap<1>:b nch_mac L=3e-08 W=2.2e-07
+ AD=1.1e-14 AS=1.1e-14 PD=3.2e-07 PS=3.2e-07 NRD=2.26737 NRS=2.26737
+ sa=8.55e-07 sb=2.05e-07 sca=1.01749 scb=2.42081e-06 scc=5.67051e-12
+ sa1=8.55e-07 sb1=2.05e-07 sa2=8.55e-07 sb2=2.05e-07 sa3=8.55e-07 sb3=2.05e-07
+ dfm_flag=1 spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.50319e-07
+ sa4=3.31124e-07 spba=1.15715e-07 spba1=1.17043e-07 sapb=1.65421e-07 enx=5e-06
+ enx1=5e-06 eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.26961e-06 rey=2.26961e-06
+ sodxa=1.235e-06 sodxb=5.9e-07 sodx=8.25147e-07 sodx1=5.39304e-07
+ sodx2=1.21519e-06 sodx4=2.91185e-07 sa5=3.65247e-07 sa6=4.75614e-07
+ sa7=2.57376e-07 sody=5.22695e-07 dw1=-1.22088e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM10@2 MM10@2:d MM10@2:g MM10@2:s Mncap<1>:b nch_mac L=3e-08 W=2.2e-07
+ AD=1.1e-14 AS=1.65e-14 PD=3.2e-07 PS=5.9e-07 NRD=2.26737 NRS=1.30437
+ sa=9.85e-07 sb=7.5e-08 sca=0.982764 scb=2.40714e-06 scc=5.67031e-12
+ sa1=9.85e-07 sb1=7.5e-08 sa2=9.85e-07 sb2=7.5e-08 sa3=9.85e-07 sb3=7.5e-08
+ dfm_flag=1 spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.13048e-07
+ sa4=1.40204e-07 spba=1.15715e-07 spba1=1.17043e-07 sapb=1.33591e-07 enx=5e-06
+ enx1=5e-06 eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.26961e-06 rey=2.26961e-06
+ sodxa=1.235e-06 sodxb=5.9e-07 sodx=8.25147e-07 sodx1=4.03049e-07
+ sodx2=1.20926e-06 sodx4=1.24301e-07 sa5=2.07084e-07 sa6=4.75107e-07
+ sa7=9.47682e-08 sody=5.22695e-07 dw1=-1.22088e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XXI0/MM1 XI0/MM1:d XI0/MM1:g XI0/MM1:s XI0/MM1:b pch_mac L=3e-08 W=4.4e-07
+ AD=3.3e-14 AS=2.2e-14 PD=1.03e-06 PS=5.4e-07 NRD=2.68958 NRS=0.441502
+ sa=7.5e-08 sb=8.55e-07 sca=59.2766 scb=0.0516242 scc=0.00806867 sa1=7.5e-08
+ sb1=8.55e-07 sa2=7.5e-08 sb2=8.55e-07 sa3=7.5e-08 sb3=8.55e-07 dfm_flag=1
+ spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.12641e-07 sa4=1.38683e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.3323e-07 enx=2.79371e-06
+ enx1=2.62018e-06 eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.47517e-06
+ rey=2.26961e-06 sodxa=9.05e-07 sodxb=1.57e-06 sodx=1.16967e-06
+ sodx1=4.56979e-07 sodx2=1.26905e-06 sodx4=1.32127e-07 sa5=2.00988e-07
+ sa6=4.57784e-07 sa7=9.47604e-08 sody=4.7877e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM9 MM9:d MM9:g MM9:s XI0/MM1:b pch_mac L=3e-08 W=4.4e-07 AD=2.2e-14 AS=2.2e-14
+ PD=5.4e-07 PS=5.4e-07 NRD=0.441502 NRS=0.441502 sa=2.05e-07 sb=7.25e-07
+ sca=38.7598 scb=0.0372475 scc=0.00364365 sa1=2.05e-07 sb1=7.25e-07
+ sa2=2.05e-07 sb2=7.25e-07 sa3=2.05e-07 sb3=7.25e-07 dfm_flag=1 spa=1e-07
+ spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.48618e-07 sa4=3.1997e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.64015e-07 enx=2.91839e-06
+ enx1=2.75909e-06 eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.49488e-06
+ rey=2.26961e-06 sodxa=9.05e-07 sodxb=1.57e-06 sodx=1.16967e-06
+ sodx1=6.0219e-07 sodx2=1.26641e-06 sodx4=3.08863e-07 sa5=3.47662e-07
+ sa6=4.48785e-07 sa7=2.56622e-07 sody=4.7877e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM9@2 MM9@2:d MM9@2:g MM9@2:s XI0/MM1:b pch_mac L=3e-08 W=4.4e-07 AD=2.2e-14
+ AS=2.2e-14 PD=5.4e-07 PS=5.4e-07 NRD=0.441502 NRS=0.441502 sa=3.35e-07
+ sb=5.95e-07 sca=33.7029 scb=0.0290217 scc=0.00291067 sa1=3.35e-07 sb1=5.95e-07
+ sa2=3.35e-07 sb2=5.95e-07 sa3=3.35e-07 sb3=5.95e-07 dfm_flag=1 spa=1e-07
+ spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.63797e-07 sa4=4.28743e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.76425e-07 enx=3.03835e-06
+ enx1=2.89288e-06 eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.51153e-06
+ rey=2.26961e-06 sodxa=9.05e-07 sodxb=1.57e-06 sodx=1.16967e-06
+ sodx1=6.9038e-07 sodx2=1.28526e-06 sodx4=4.55104e-07 sa5=4.35665e-07
+ sa6=4.57039e-07 sa7=3.99716e-07 sody=4.7877e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM2 MM2:d MM2:g MM2:s XI0/MM1:b pch_mac L=3e-08 W=4.4e-07 AD=2.2e-14 AS=2.2e-14
+ PD=5.4e-07 PS=5.4e-07 NRD=0.441502 NRS=0.441502 sa=4.65e-07 sb=4.65e-07
+ sca=32.5367 scb=0.0266096 scc=0.00282276 sa1=4.65e-07 sb1=4.65e-07
+ sa2=4.65e-07 sb2=4.65e-07 sa3=4.65e-07 sb3=4.65e-07 dfm_flag=1 spa=1e-07
+ spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.68279e-07 sa4=4.65e-07 spba=1.15715e-07
+ spba1=1.17043e-07 sapb=1.80033e-07 enx=3.15397e-06 enx1=3.02181e-06 eny=5e-06
+ eny1=5e-06 eny2=5e-06 rex=2.52547e-06 rey=2.26961e-06 sodxa=9.05e-07
+ sodxb=1.57e-06 sodx=1.16967e-06 sodx1=7.29499e-07 sodx2=1.30969e-06
+ sodx4=5.31583e-07 sa5=4.65e-07 sa6=4.65e-07 sa7=4.65e-07 sody=4.7877e-07
+ dw1=-1.4923e-20 dw=0 dvt_dfm=0 spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60
+ spmb=1.11111e+15 spomb=0 spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM2@4 MM2@4:d MM2@4:g MM2@4:s XI0/MM1:b pch_mac L=3e-08 W=4.4e-07 AD=2.2e-14
+ AS=2.2e-14 PD=5.4e-07 PS=5.4e-07 NRD=0.441502 NRS=0.441502 sa=5.95e-07
+ sb=3.35e-07 sca=33.7029 scb=0.0290217 scc=0.00291067 sa1=5.95e-07 sb1=3.35e-07
+ sa2=5.95e-07 sb2=3.35e-07 sa3=5.95e-07 sb3=3.35e-07 dfm_flag=1 spa=1e-07
+ spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.63797e-07 sa4=4.28743e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.76425e-07 enx=3.26557e-06
+ enx1=3.14614e-06 eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.53699e-06
+ rey=2.26961e-06 sodxa=9.05e-07 sodxb=1.57e-06 sodx=1.16967e-06
+ sodx1=7.1941e-07 sodx2=1.319e-06 sodx4=4.80642e-07 sa5=4.35665e-07
+ sa6=4.57039e-07 sa7=3.99716e-07 sody=4.7877e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM2@3 MM2@3:d MM2@3:g MM2@3:s XI0/MM1:b pch_mac L=3e-08 W=4.4e-07 AD=2.2e-14
+ AS=2.2e-14 PD=5.4e-07 PS=5.4e-07 NRD=0.441502 NRS=0.441502 sa=7.25e-07
+ sb=2.05e-07 sca=38.7598 scb=0.0372475 scc=0.00364365 sa1=7.25e-07 sb1=2.05e-07
+ sa2=7.25e-07 sb2=2.05e-07 sa3=7.25e-07 sb3=2.05e-07 dfm_flag=1 spa=1e-07
+ spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.48618e-07 sa4=3.1997e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.64015e-07 enx=3.37344e-06
+ enx1=3.26613e-06 eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.5463e-06
+ rey=2.26961e-06 sodxa=9.05e-07 sodxb=1.57e-06 sodx=1.16967e-06
+ sodx1=6.5395e-07 sodx2=1.32331e-06 sodx4=3.32965e-07 sa5=3.47662e-07
+ sa6=4.48785e-07 sa7=2.56622e-07 sody=4.7877e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM2@2 MM2@2:d MM2@2:g MM2@2:s XI0/MM1:b pch_mac L=3e-08 W=4.4e-07 AD=2.2e-14
+ AS=3.3e-14 PD=5.4e-07 PS=1.03e-06 NRD=0.441502 NRS=2.68958 sa=8.55e-07
+ sb=7.5e-08 sca=59.2766 scb=0.0516242 scc=0.00806867 sa1=8.55e-07 sb1=7.5e-08
+ sa2=8.55e-07 sb2=7.5e-08 sa3=8.55e-07 sb3=7.5e-08 dfm_flag=1 spa=1e-07
+ spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.12641e-07 sa4=1.38683e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.3323e-07 enx=3.47785e-06
+ enx1=3.38198e-06 eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.55358e-06
+ rey=2.26961e-06 sodxa=9.05e-07 sodxb=1.57e-06 sodx=1.16967e-06
+ sodx1=5.17248e-07 sodx2=1.34007e-06 sodx4=1.42929e-07 sa5=2.00988e-07
+ sa6=4.57784e-07 sa7=9.47604e-08 sody=4.7877e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM1 MM1:d MM1:g MM1:s Mpcap<1>:b pch_mac L=3e-08 W=2.2e-07 AD=1.1e-14
+ AS=1.65e-14 PD=3.2e-07 PS=5.9e-07 NRD=0.88498 NRS=6.57357 sa=7.5e-08
+ sb=9.85e-07 sca=34.1997 scb=0.030463 scc=0.00527433 sa1=7.5e-08 sb1=9.85e-07
+ sa2=7.5e-08 sb2=9.85e-07 sa3=7.5e-08 sb3=9.85e-07 dfm_flag=1 spa=1e-07
+ spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.13048e-07 sa4=1.40204e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.33591e-07 enx=5e-06 enx1=5e-06
+ eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.26961e-06 rey=2.26961e-06
+ sodxa=1.235e-06 sodxb=5.9e-07 sodx=8.25147e-07 sodx1=4.79541e-07
+ sodx2=1.31202e-06 sodx4=1.38122e-07 sa5=2.07084e-07 sa6=4.75107e-07
+ sa7=9.47682e-08 sody=7.33008e-07 dw1=-1.22088e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM1@4 MM1@4:d MM1@4:g MM1@4:s Mpcap<1>:b pch_mac L=3e-08 W=2.2e-07 AD=1.1e-14
+ AS=1.1e-14 PD=3.2e-07 PS=3.2e-07 NRD=0.88498 NRS=0.88498 sa=2.05e-07
+ sb=8.55e-07 sca=13.2524 scb=0.0158428 scc=0.000849143 sa1=2.05e-07
+ sb1=8.55e-07 sa2=2.05e-07 sb2=8.55e-07 sa3=2.05e-07 sb3=8.55e-07 dfm_flag=1
+ spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.50319e-07 sa4=3.31124e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.65421e-07 enx=5e-06 enx1=5e-06
+ eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.26961e-06 rey=2.26961e-06
+ sodxa=1.235e-06 sodxb=5.9e-07 sodx=8.25147e-07 sodx1=6.10366e-07
+ sodx2=1.30487e-06 sodx4=3.22634e-07 sa5=3.65247e-07 sa6=4.75614e-07
+ sa7=2.57376e-07 sody=7.33008e-07 dw1=-1.22088e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM1@3 MM1@3:d MM1@3:g MM1@3:s Mpcap<1>:b pch_mac L=3e-08 W=2.2e-07 AD=1.1e-14
+ AS=1.1e-14 PD=3.2e-07 PS=3.2e-07 NRD=0.88498 NRS=0.88498 sa=3.35e-07
+ sb=7.25e-07 sca=7.50908 scb=0.00696192 scc=0.000114672 sa1=3.35e-07
+ sb1=7.25e-07 sa2=3.35e-07 sb2=7.25e-07 sa3=3.35e-07 sb3=7.25e-07 dfm_flag=1
+ spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.67481e-07 sa4=4.58405e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.79393e-07 enx=5e-06 enx1=5e-06
+ eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.26961e-06 rey=2.26961e-06
+ sodxa=1.235e-06 sodxb=5.9e-07 sodx=8.25147e-07 sodx1=6.79054e-07
+ sodx2=1.31545e-06 sodx4=4.7489e-07 sa5=4.70689e-07 sa6=4.98953e-07
+ sa7=4.09222e-07 sody=7.33008e-07 dw1=-1.22088e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM1@2 MM1@2:d MM1@2:g MM1@2:s Mpcap<1>:b pch_mac L=3e-08 W=2.2e-07 AD=1.1e-14
+ AS=1.1e-14 PD=3.2e-07 PS=3.2e-07 NRD=0.88498 NRS=0.88498 sa=4.65e-07
+ sb=5.95e-07 sca=5.14906 scb=0.0028576 scc=1.42335e-05 sa1=4.65e-07
+ sb1=5.95e-07 sa2=4.65e-07 sb2=5.95e-07 sa3=4.65e-07 sb3=5.95e-07 dfm_flag=1
+ spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.74881e-07 sa4=5.22045e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.85305e-07 enx=5e-06 enx1=5e-06
+ eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.26961e-06 rey=2.26961e-06
+ sodxa=1.235e-06 sodxb=5.9e-07 sodx=8.25147e-07 sodx1=7.01269e-07
+ sodx2=1.32202e-06 sodx4=5.61978e-07 sa5=5.2341e-07 sa6=5.25653e-07
+ sa7=5.14436e-07 sody=7.33008e-07 dw1=-1.22088e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM0 MM0:d MM0:g MM0:s Mpcap<1>:b pch_mac L=3e-08 W=2.2e-07 AD=1.1e-14
+ AS=1.1e-14 PD=3.2e-07 PS=3.2e-07 NRD=0.88498 NRS=0.88498 sa=5.95e-07
+ sb=4.65e-07 sca=3.9552 scb=0.00116539 scc=1.69869e-06 sa1=5.95e-07
+ sb1=4.65e-07 sa2=5.95e-07 sb2=4.65e-07 sa3=5.95e-07 sb3=4.65e-07 dfm_flag=1
+ spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.74881e-07 sa4=5.22045e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.85305e-07 enx=5e-06 enx1=5e-06
+ eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.26961e-06 rey=2.26961e-06
+ sodxa=1.235e-06 sodxb=5.9e-07 sodx=8.25147e-07 sodx1=6.84169e-07
+ sodx2=1.29632e-06 sodx4=5.4162e-07 sa5=5.2341e-07 sa6=5.25653e-07
+ sa7=5.14436e-07 sody=7.33008e-07 dw1=-1.22088e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM0@4 MM0@4:d MM0@4:g MM0@4:s Mpcap<1>:b pch_mac L=3e-08 W=2.2e-07 AD=1.1e-14
+ AS=1.1e-14 PD=3.2e-07 PS=3.2e-07 NRD=0.88498 NRS=0.88498 sa=7.25e-07
+ sb=3.35e-07 sca=3.26879 scb=0.000510331 scc=2.15763e-07 sa1=7.25e-07
+ sb1=3.35e-07 sa2=7.25e-07 sb2=3.35e-07 sa3=7.25e-07 sb3=3.35e-07 dfm_flag=1
+ spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.67481e-07 sa4=4.58405e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.79393e-07 enx=5e-06 enx1=5e-06
+ eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.26961e-06 rey=2.26961e-06
+ sodxa=1.235e-06 sodxb=5.9e-07 sodx=8.25147e-07 sodx1=6.30535e-07
+ sodx2=1.24897e-06 sodx4=4.35686e-07 sa5=4.70689e-07 sa6=4.98953e-07
+ sa7=4.09222e-07 sody=7.33008e-07 dw1=-1.22088e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM0@3 MM0@3:d MM0@3:g MM0@3:s Mpcap<1>:b pch_mac L=3e-08 W=2.2e-07 AD=1.1e-14
+ AS=1.1e-14 PD=3.2e-07 PS=3.2e-07 NRD=0.88498 NRS=0.88498 sa=8.55e-07
+ sb=2.05e-07 sca=2.83821 scb=0.000266723 scc=4.63789e-08 sa1=8.55e-07
+ sb1=2.05e-07 sa2=8.55e-07 sb2=2.05e-07 sa3=8.55e-07 sb3=2.05e-07 dfm_flag=1
+ spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.50319e-07 sa4=3.31124e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.65421e-07 enx=5e-06 enx1=5e-06
+ eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.26961e-06 rey=2.26961e-06
+ sodxa=1.235e-06 sodxb=5.9e-07 sodx=8.25147e-07 sodx1=5.39304e-07
+ sodx2=1.21519e-06 sodx4=2.91185e-07 sa5=3.65247e-07 sa6=4.75614e-07
+ sa7=2.57376e-07 sody=7.33008e-07 dw1=-1.22088e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM0@2 MM0@2:d MM0@2:g MM0@2:s Mpcap<1>:b pch_mac L=3e-08 W=2.2e-07 AD=1.1e-14
+ AS=1.65e-14 PD=3.2e-07 PS=5.9e-07 NRD=0.88498 NRS=6.57357 sa=9.85e-07
+ sb=7.5e-08 sca=2.55049 scb=0.000178607 scc=2.75064e-08 sa1=9.85e-07
+ sb1=7.5e-08 sa2=9.85e-07 sb2=7.5e-08 sa3=9.85e-07 sb3=7.5e-08 dfm_flag=1
+ spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.13048e-07 sa4=1.40204e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.33591e-07 enx=5e-06 enx1=5e-06
+ eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.26961e-06 rey=2.26961e-06
+ sodxa=1.235e-06 sodxb=5.9e-07 sodx=8.25147e-07 sodx1=4.03049e-07
+ sodx2=1.20926e-06 sodx4=1.24301e-07 sa5=2.07084e-07 sa6=4.75107e-07
+ sa7=9.47682e-08 sody=7.33008e-07 dw1=-1.22088e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMpcap<1> Mpcap<1>:d Mpcap<1>:g Mpcap<1>:s Mpcap<1>:b pch_mac L=1e-06 W=1e-06
+ AD=9.5e-14 AS=6e-14 PD=2.19e-06 PS=1.12e-06 NRD=0.111164 NRS=0.120978
+ sa=9.5e-08 sb=1.2415e-05 sca=1.37148 scb=3.51376e-05 scc=5.67692e-09
+ sa1=9.5e-08 sb1=1.2415e-05 sa2=9.5e-08 sb2=1.2415e-05 sa3=9.5e-08
+ sb3=1.2415e-05 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07 spa3=1.2e-07
+ sap=1.40863e-07 sa4=1.89446e-07 spba=1.96927e-07 spba1=2.57596e-07
+ sapb=1.52447e-07 enx=5e-06 enx1=5e-06 eny=5e-06 eny1=5e-06 eny2=5e-06
+ rex=3.16263e-06 rey=3.16263e-06 sodxa=1.81013e-06 sodxb=2.62e-06
+ sodx=2.15923e-06 sodx1=6.68181e-07 sodx2=1.45481e-06 sodx4=1.78203e-07
+ sa5=2.93604e-07 sa6=5.17837e-07 sa7=1.19981e-07 sody=3.02112e-07
+ dw1=-1.4923e-20 dw=0 dvt_dfm=0 spmt=1.3e-07 spomt=1.24e-06 spomt1=1.3629e-08
+ spmb=1.11111e+15 spomb=0 spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMpcap<1>__2 Mpcap<1>__2:d Mpcap<1>__2:g Mpcap<1>__2:s Mpcap<1>:b pch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.120978
+ NRS=0.120978 sa=1.215e-06 sb=1.1295e-05 sca=1.24634 scb=3.51286e-05
+ scc=5.67691e-09 sa1=1.215e-06 sb1=1.1295e-05 sa2=1.215e-06 sb2=1.1295e-05
+ sa3=1.215e-06 sb3=1.1295e-05 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=3.17891e-07 sa4=2.18901e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.32542e-06 enx=5e-06 enx1=5e-06 eny=5e-06 eny1=5e-06
+ eny2=5e-06 rex=3.16263e-06 rey=3.16263e-06 sodxa=1.81013e-06 sodxb=1.5e-06
+ sodx=1.64415e-06 sodx1=2.151e-06 sodx2=3.09015e-06 sodx4=1.56846e-06
+ sa5=2.25832e-06 sa6=1.5493e-06 sa7=1.5304e-06 sody=3.02112e-07 dw1=-1.4923e-20
+ dw=0 dvt_dfm=0 spmt=1.3e-07 spomt=1.24e-06 spomt1=1.3629e-08 spmb=1.11111e+15
+ spomb=0 spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMpcap<1>__3 Mpcap<1>__3:d Mpcap<1>__3:g Mpcap<1>__3:s Mpcap<1>:b pch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.120978
+ NRS=0.120978 sa=2.335e-06 sb=1.0175e-05 sca=1.20199 scb=3.51286e-05
+ scc=5.67691e-09 sa1=2.335e-06 sb1=1.0175e-05 sa2=2.335e-06 sb2=1.0175e-05
+ sa3=2.335e-06 sb3=1.0175e-05 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=3.81985e-07 sa4=3.79878e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.52118e-06 enx=5e-06 enx1=5e-06 eny=5e-06 eny1=5e-06
+ eny2=5e-06 rex=3.16263e-06 rey=3.16263e-06 sodxa=1.81013e-06 sodxb=1.205e-06
+ sodx=1.46171e-06 sodx1=2.96155e-06 sodx2=5.29297e-06 sodx4=2.73432e-06
+ sa5=3.84122e-06 sa6=2.93522e-06 sa7=2.93043e-06 sody=3.02112e-07
+ dw1=-1.4923e-20 dw=0 dvt_dfm=0 spmt=1.3e-07 spomt=1.24e-06 spomt1=1.3629e-08
+ spmb=1.11111e+15 spomb=0 spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMpcap<1>__4 Mpcap<1>__4:d Mpcap<1>__4:g Mpcap<1>__4:s Mpcap<1>:b pch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.120978
+ NRS=0.120978 sa=3.455e-06 sb=9.055e-06 sca=1.18122 scb=3.51286e-05
+ scc=5.67691e-09 sa1=3.455e-06 sb1=9.055e-06 sa2=3.455e-06 sb2=9.055e-06
+ sa3=3.455e-06 sb3=9.055e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=4.18663e-07 sa4=5.00183e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.62946e-06 enx=5e-06 enx1=5e-06 eny=5e-06 eny1=5e-06
+ eny2=5e-06 rex=3.16263e-06 rey=3.16263e-06 sodxa=1.81013e-06 sodxb=1.205e-06
+ sodx=1.46171e-06 sodx1=3.48202e-06 sodx2=7.28249e-06 sodx4=3.76958e-06
+ sa5=5.02348e-06 sa6=4.27729e-06 sa7=4.27551e-06 sody=3.02112e-07
+ dw1=-1.4923e-20 dw=0 dvt_dfm=0 spmt=1.3e-07 spomt=1.24e-06 spomt1=1.3629e-08
+ spmb=1.11111e+15 spomb=0 spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMpcap<1>__5 Mpcap<1>__5:d Mpcap<1>__5:g Mpcap<1>__5:s Mpcap<1>:b pch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.120978
+ NRS=0.120978 sa=4.575e-06 sb=7.935e-06 sca=1.17735 scb=3.51286e-05
+ scc=5.67691e-09 sa1=4.575e-06 sb1=7.935e-06 sa2=4.575e-06 sb2=7.935e-06
+ sa3=4.575e-06 sb3=7.935e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=4.39936e-07 sa4=5.80386e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.69117e-06 enx=5e-06 enx1=5e-06 eny=5e-06 eny1=5e-06
+ eny2=5e-06 rex=3.16263e-06 rey=3.16263e-06 sodxa=1.81013e-06 sodxb=1.205e-06
+ sodx=1.46171e-06 sodx1=3.78287e-06 sodx2=8.88295e-06 sodx4=4.60019e-06
+ sa5=5.81165e-06 sa6=5.4376e-06 sa7=5.43701e-06 sody=3.02112e-07
+ dw1=-1.4923e-20 dw=0 dvt_dfm=0 spmt=1.3e-07 spomt=1.24e-06 spomt1=1.3629e-08
+ spmb=1.11111e+15 spomb=0 spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMpcap<1>__6 Mpcap<1>__6:d Mpcap<1>__6:g Mpcap<1>__6:s Mpcap<1>:b pch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.120978
+ NRS=0.120978 sa=5.695e-06 sb=6.815e-06 sca=1.17735 scb=3.51286e-05
+ scc=5.67691e-09 sa1=5.695e-06 sb1=6.815e-06 sa2=5.695e-06 sb2=6.815e-06
+ sa3=5.695e-06 sb3=6.815e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=4.49842e-07 sa4=6.20487e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.71965e-06 enx=5e-06 enx1=5e-06 eny=5e-06 eny1=5e-06
+ eny2=5e-06 rex=3.16263e-06 rey=3.16263e-06 sodxa=1.81013e-06 sodxb=1.205e-06
+ sodx=1.46171e-06 sodx1=3.90135e-06 sodx2=9.7551e-06 sodx4=5.05253e-06
+ sa5=6.20574e-06 sa6=6.156e-06 sa7=6.15593e-06 sody=3.02112e-07 dw1=-1.4923e-20
+ dw=0 dvt_dfm=0 spmt=1.3e-07 spomt=1.24e-06 spomt1=1.3629e-08 spmb=1.11111e+15
+ spomb=0 spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMpcap<1>__7 Mpcap<1>__7:d Mpcap<1>__7:g Mpcap<1>__7:s Mpcap<1>:b pch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.120978
+ NRS=0.120978 sa=6.815e-06 sb=5.695e-06 sca=1.17735 scb=3.51286e-05
+ scc=5.67691e-09 sa1=6.815e-06 sb1=5.695e-06 sa2=6.815e-06 sb2=5.695e-06
+ sa3=6.815e-06 sb3=5.695e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=4.49842e-07 sa4=6.20487e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.71965e-06 enx=5e-06 enx1=5e-06 eny=5e-06 eny1=5e-06
+ eny2=5e-06 rex=3.16263e-06 rey=3.16263e-06 sodxa=1.81013e-06 sodxb=1.205e-06
+ sodx=1.46171e-06 sodx1=3.85523e-06 sodx2=9.60765e-06 sodx4=4.97613e-06
+ sa5=6.20574e-06 sa6=6.156e-06 sa7=6.15593e-06 sody=3.02112e-07 dw1=-1.4923e-20
+ dw=0 dvt_dfm=0 spmt=1.3e-07 spomt=1.24e-06 spomt1=1.3629e-08 spmb=1.11111e+15
+ spomb=0 spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMpcap<1>__8 Mpcap<1>__8:d Mpcap<1>__8:g Mpcap<1>__8:s Mpcap<1>:b pch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.120978
+ NRS=0.120978 sa=7.935e-06 sb=4.575e-06 sca=1.1899 scb=3.51286e-05
+ scc=5.67691e-09 sa1=7.935e-06 sb1=4.575e-06 sa2=7.935e-06 sb2=4.575e-06
+ sa3=7.935e-06 sb3=4.575e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=4.39936e-07 sa4=5.80386e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.69117e-06 enx=5e-06 enx1=5e-06 eny=5e-06 eny1=5e-06
+ eny2=5e-06 rex=3.16263e-06 rey=3.16263e-06 sodxa=1.81013e-06 sodxb=1.205e-06
+ sodx=1.46171e-06 sodx1=3.65028e-06 sodx2=8.54027e-06 sodx4=4.42267e-06
+ sa5=5.81165e-06 sa6=5.4376e-06 sa7=5.43701e-06 sody=3.02112e-07
+ dw1=-1.4923e-20 dw=0 dvt_dfm=0 spmt=1.3e-07 spomt=1.24e-06 spomt1=1.3629e-08
+ spmb=1.11111e+15 spomb=0 spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMpcap<1>__9 Mpcap<1>__9:d Mpcap<1>__9:g Mpcap<1>__9:s Mpcap<1>:b pch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.120978
+ NRS=0.120978 sa=9.055e-06 sb=3.455e-06 sca=1.21951 scb=3.51286e-05
+ scc=5.67691e-09 sa1=9.055e-06 sb1=3.455e-06 sa2=9.055e-06 sb2=3.455e-06
+ sa3=9.055e-06 sb3=3.455e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=4.18663e-07 sa4=5.00183e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.62946e-06 enx=5e-06 enx1=5e-06 eny=5e-06 eny1=5e-06
+ eny2=5e-06 rex=3.16263e-06 rey=3.16263e-06 sodxa=1.81013e-06 sodxb=1.205e-06
+ sodx=1.46171e-06 sodx1=3.28091e-06 sodx2=6.91376e-06 sodx4=3.57867e-06
+ sa5=5.02348e-06 sa6=4.27729e-06 sa7=4.27551e-06 sody=3.02112e-07
+ dw1=-1.4923e-20 dw=0 dvt_dfm=0 spmt=1.3e-07 spomt=1.24e-06 spomt1=1.3629e-08
+ spmb=1.11111e+15 spomb=0 spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMpcap<1>__10 Mpcap<1>__10:d Mpcap<1>__10:g Mpcap<1>__10:s Mpcap<1>:b pch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.120978
+ NRS=0.120978 sa=1.0175e-05 sb=2.335e-06 sca=1.29054 scb=3.51287e-05
+ scc=5.67691e-09 sa1=1.0175e-05 sb1=2.335e-06 sa2=1.0175e-05 sb2=2.335e-06
+ sa3=1.0175e-05 sb3=2.335e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=3.81985e-07 sa4=3.79878e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.52118e-06 enx=5e-06 enx1=5e-06 eny=5e-06 eny1=5e-06
+ eny2=5e-06 rex=3.16263e-06 rey=3.16263e-06 sodxa=1.81013e-06 sodxb=1.205e-06
+ sodx=1.46171e-06 sodx1=2.72473e-06 sodx2=5.00111e-06 sodx4=2.58351e-06
+ sa5=3.84122e-06 sa6=2.93522e-06 sa7=2.93043e-06 sody=3.02112e-07
+ dw1=-1.4923e-20 dw=0 dvt_dfm=0 spmt=1.3e-07 spomt=1.24e-06 spomt1=1.3629e-08
+ spmb=1.11111e+15 spomb=0 spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMpcap<1>__11 Mpcap<1>__11:d Mpcap<1>__11:g Mpcap<1>__11:s Mpcap<1>:b pch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.120978
+ NRS=0.120978 sa=1.1295e-05 sb=1.215e-06 sca=1.5466 scb=3.61198e-05
+ scc=5.68022e-09 sa1=1.1295e-05 sb1=1.215e-06 sa2=1.1295e-05 sb2=1.215e-06
+ sa3=1.1295e-05 sb3=1.215e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=3.17891e-07 sa4=2.18901e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.32542e-06 enx=4.45442e-06 enx1=4.43209e-06 eny=5e-06
+ eny1=5e-06 eny2=5e-06 rex=3.30453e-06 rey=3.16263e-06 sodxa=2.23292e-06
+ sodxb=1.205e-06 sodx=1.60193e-06 sodx1=1.92783e-06 sodx2=2.91608e-06
+ sodx4=1.48009e-06 sa5=2.25832e-06 sa6=1.5493e-06 sa7=1.5304e-06
+ sody=3.02112e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0 spmt=1.3e-07 spomt=1.24e-06
+ spomt1=1.3629e-08 spmb=1.11111e+15 spomb=0 spomb1=1.11111e+60 _ccoflag=0
+ _rcoflag=0 _rgflag=0
XMpcap<1>__12 Mpcap<1>__12:d Mpcap<1>__12:g Mpcap<1>__12:s Mpcap<1>:b pch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=9.5e-14 PD=1.12e-06 PS=2.19e-06 NRD=0.120978
+ NRS=0.111164 sa=1.2415e-05 sb=9.5e-08 sca=6.28749 scb=0.00517509
+ scc=0.000349142 sa1=1.2415e-05 sb1=9.5e-08 sa2=1.2415e-05 sb2=9.5e-08
+ sa3=1.2415e-05 sb3=9.5e-08 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=1.40863e-07 sa4=1.89446e-07 spba=1.96927e-07
+ spba1=2.57596e-07 sapb=1.52447e-07 enx=3.75443e-06 enx1=3.63876e-06 eny=5e-06
+ eny1=5e-06 eny2=5e-06 rex=3.29331e-06 rey=3.16263e-06 sodxa=3.36216e-06
+ sodxb=1.205e-06 sodx=1.88596e-06 sodx1=5.85085e-07 sodx2=1.37266e-06
+ sodx4=1.6814e-07 sa5=2.93604e-07 sa6=5.17837e-07 sa7=1.19981e-07
+ sody=3.02112e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0 spmt=1.3e-07 spomt=1.24e-06
+ spomt1=1.3629e-08 spmb=1.11111e+15 spomb=0 spomb1=1.11111e+60 _ccoflag=0
+ _rcoflag=0 _rgflag=0
XMpcap<0> Mpcap<0>:d Mpcap<0>:g Mpcap<0>:s Mpcap<1>:b pch_mac L=1e-06 W=1e-06
+ AD=9.5e-14 AS=6e-14 PD=2.19e-06 PS=1.12e-06 NRD=0.111164 NRS=0.120978
+ sa=9.5e-08 sb=1.2415e-05 sca=11.0812 scb=0.00839397 scc=0.00121277 sa1=9.5e-08
+ sb1=1.2415e-05 sa2=9.5e-08 sb2=1.2415e-05 sa3=9.5e-08 sb3=1.2415e-05
+ dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07 spa3=1.2e-07 sap=1.40863e-07
+ sa4=1.89446e-07 spba=1.96927e-07 spba1=2.57596e-07 sapb=1.52447e-07 enx=5e-06
+ enx1=5e-06 eny=4.40961e-06 eny1=4.33709e-06 eny2=4.39778e-06 rex=3.16263e-06
+ rey=3.30763e-06 sodxa=2.915e-06 sodxb=2.62e-06 sodx=2.7616e-06
+ sodx1=7.8107e-07 sodx2=1.55728e-06 sodx4=1.90756e-07 sa5=2.93604e-07
+ sa6=5.17837e-07 sa7=1.19981e-07 sody=5.1922e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.3e-07 spomb=1.24e-06
+ spomb1=1.3629e-08 _ccoflag=0 _rcoflag=0 _rgflag=0
XMpcap<0>__2 Mpcap<0>__2:d Mpcap<0>__2:g Mpcap<0>__2:s Mpcap<1>:b pch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.120978
+ NRS=0.120978 sa=1.215e-06 sb=1.1295e-05 sca=10.9561 scb=0.00839396
+ scc=0.00121277 sa1=1.215e-06 sb1=1.1295e-05 sa2=1.215e-06 sb2=1.1295e-05
+ sa3=1.215e-06 sb3=1.1295e-05 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=3.17891e-07 sa4=2.18901e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.32542e-06 enx=5e-06 enx1=5e-06 eny=4.40961e-06
+ eny1=4.33709e-06 eny2=4.39778e-06 rex=3.16263e-06 rey=3.30763e-06
+ sodxa=2.915e-06 sodxb=1.5e-06 sodx=2.03441e-06 sodx1=2.47017e-06
+ sodx2=3.30741e-06 sodx4=1.67875e-06 sa5=2.25832e-06 sa6=1.5493e-06
+ sa7=1.5304e-06 sody=5.1922e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0 spmt=1.11111e+15
+ spomt=0 spomt1=1.11111e+60 spmb=1.3e-07 spomb=1.24e-06 spomb1=1.3629e-08
+ _ccoflag=0 _rcoflag=0 _rgflag=0
XMpcap<0>__3 Mpcap<0>__3:d Mpcap<0>__3:g Mpcap<0>__3:s Mpcap<1>:b pch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.120978
+ NRS=0.120978 sa=2.335e-06 sb=1.0175e-05 sca=10.9117 scb=0.00839396
+ scc=0.00121277 sa1=2.335e-06 sb1=1.0175e-05 sa2=2.335e-06 sb2=1.0175e-05
+ sa3=2.335e-06 sb3=1.0175e-05 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=3.81985e-07 sa4=3.79878e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.52118e-06 enx=5e-06 enx1=5e-06 eny=4.40961e-06
+ eny1=4.33709e-06 eny2=4.39778e-06 rex=3.16263e-06 rey=3.30763e-06
+ sodxa=2.915e-06 sodxb=1.205e-06 sodx=1.78567e-06 sodx1=3.33757e-06
+ sodx2=5.65938e-06 sodx4=2.92364e-06 sa5=3.84122e-06 sa6=2.93522e-06
+ sa7=2.93043e-06 sody=5.1922e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.3e-07 spomb=1.24e-06
+ spomb1=1.3629e-08 _ccoflag=0 _rcoflag=0 _rgflag=0
XMpcap<0>__4 Mpcap<0>__4:d Mpcap<0>__4:g Mpcap<0>__4:s Mpcap<1>:b pch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.120978
+ NRS=0.120978 sa=3.455e-06 sb=9.055e-06 sca=10.891 scb=0.00839396
+ scc=0.00121277 sa1=3.455e-06 sb1=9.055e-06 sa2=3.455e-06 sb2=9.055e-06
+ sa3=3.455e-06 sb3=9.055e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=4.18663e-07 sa4=5.00183e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.62946e-06 enx=5e-06 enx1=5e-06 eny=4.40961e-06
+ eny1=4.33709e-06 eny2=4.39778e-06 rex=3.16263e-06 rey=3.30763e-06
+ sodxa=2.915e-06 sodxb=1.205e-06 sodx=1.78567e-06 sodx1=3.86094e-06
+ sodx2=7.75756e-06 sodx4=4.01554e-06 sa5=5.02348e-06 sa6=4.27729e-06
+ sa7=4.27551e-06 sody=5.1922e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.3e-07 spomb=1.24e-06
+ spomb1=1.3629e-08 _ccoflag=0 _rcoflag=0 _rgflag=0
XMpcap<0>__5 Mpcap<0>__5:d Mpcap<0>__5:g Mpcap<0>__5:s Mpcap<1>:b pch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.120978
+ NRS=0.120978 sa=4.575e-06 sb=7.935e-06 sca=10.8871 scb=0.00839396
+ scc=0.00121277 sa1=4.575e-06 sb1=7.935e-06 sa2=4.575e-06 sb2=7.935e-06
+ sa3=4.575e-06 sb3=7.935e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=4.39936e-07 sa4=5.80386e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.69117e-06 enx=5e-06 enx1=5e-06 eny=4.40961e-06
+ eny1=4.33709e-06 eny2=4.39778e-06 rex=3.16263e-06 rey=3.30763e-06
+ sodxa=2.915e-06 sodxb=1.205e-06 sodx=1.78567e-06 sodx1=4.13095e-06
+ sodx2=9.3739e-06 sodx4=4.85448e-06 sa5=5.81165e-06 sa6=5.4376e-06
+ sa7=5.43701e-06 sody=5.1922e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.3e-07 spomb=1.24e-06
+ spomb1=1.3629e-08 _ccoflag=0 _rcoflag=0 _rgflag=0
XMpcap<0>__6 Mpcap<0>__6:d Mpcap<0>__6:g Mpcap<0>__6:s Mpcap<1>:b pch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.120978
+ NRS=0.120978 sa=5.695e-06 sb=6.815e-06 sca=10.8871 scb=0.00839396
+ scc=0.00121277 sa1=5.695e-06 sb1=6.815e-06 sa2=5.695e-06 sb2=6.815e-06
+ sa3=5.695e-06 sb3=6.815e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=4.49842e-07 sa4=6.20487e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.71965e-06 enx=5e-06 enx1=5e-06 eny=4.40961e-06
+ eny1=4.33709e-06 eny2=4.39778e-06 rex=3.16263e-06 rey=3.30763e-06
+ sodxa=2.915e-06 sodxb=1.205e-06 sodx=1.78567e-06 sodx1=4.19942e-06
+ sodx2=1.01297e-05 sodx4=5.24659e-06 sa5=6.20574e-06 sa6=6.156e-06
+ sa7=6.15593e-06 sody=5.1922e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.3e-07 spomb=1.24e-06
+ spomb1=1.3629e-08 _ccoflag=0 _rcoflag=0 _rgflag=0
XMpcap<0>__7 Mpcap<0>__7:d Mpcap<0>__7:g Mpcap<0>__7:s Mpcap<1>:b pch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.120978
+ NRS=0.120978 sa=6.815e-06 sb=5.695e-06 sca=10.8871 scb=0.00839396
+ scc=0.00121277 sa1=6.815e-06 sb1=5.695e-06 sa2=6.815e-06 sb2=5.695e-06
+ sa3=6.815e-06 sb3=5.695e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=4.49842e-07 sa4=6.20487e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.71965e-06 enx=5e-06 enx1=5e-06 eny=4.40961e-06
+ eny1=4.33709e-06 eny2=4.39778e-06 rex=3.16263e-06 rey=3.30763e-06
+ sodxa=2.915e-06 sodxb=1.205e-06 sodx=1.78567e-06 sodx1=4.09372e-06
+ sodx2=9.80409e-06 sodx4=5.07786e-06 sa5=6.20574e-06 sa6=6.156e-06
+ sa7=6.15593e-06 sody=5.1922e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.3e-07 spomb=1.24e-06
+ spomb1=1.3629e-08 _ccoflag=0 _rcoflag=0 _rgflag=0
XMpcap<0>__8 Mpcap<0>__8:d Mpcap<0>__8:g Mpcap<0>__8:s Mpcap<1>:b pch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.120978
+ NRS=0.120978 sa=7.935e-06 sb=4.575e-06 sca=10.8996 scb=0.00839396
+ scc=0.00121277 sa1=7.935e-06 sb1=4.575e-06 sa2=7.935e-06 sb2=4.575e-06
+ sa3=7.935e-06 sb3=4.575e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=4.39936e-07 sa4=5.80386e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.69117e-06 enx=5e-06 enx1=5e-06 eny=4.40961e-06
+ eny1=4.33709e-06 eny2=4.39778e-06 rex=3.16263e-06 rey=3.30763e-06
+ sodxa=2.915e-06 sodxb=1.205e-06 sodx=1.78567e-06 sodx1=3.82652e-06
+ sodx2=8.61161e-06 sodx4=4.45959e-06 sa5=5.81165e-06 sa6=5.4376e-06
+ sa7=5.43701e-06 sody=5.1922e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.3e-07 spomb=1.24e-06
+ spomb1=1.3629e-08 _ccoflag=0 _rcoflag=0 _rgflag=0
XMpcap<0>__9 Mpcap<0>__9:d Mpcap<0>__9:g Mpcap<0>__9:s Mpcap<1>:b pch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.120978
+ NRS=0.120978 sa=9.055e-06 sb=3.455e-06 sca=10.9293 scb=0.00839396
+ scc=0.00121277 sa1=9.055e-06 sb1=3.455e-06 sa2=9.055e-06 sb2=3.455e-06
+ sa3=9.055e-06 sb3=3.455e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=4.18663e-07 sa4=5.00183e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.62946e-06 enx=5e-06 enx1=5e-06 eny=4.40961e-06
+ eny1=4.33709e-06 eny2=4.39778e-06 rex=3.16263e-06 rey=3.30763e-06
+ sodxa=2.915e-06 sodxb=1.205e-06 sodx=1.78567e-06 sodx1=3.39761e-06
+ sodx2=6.93208e-06 sodx4=3.58813e-06 sa5=5.02348e-06 sa6=4.27729e-06
+ sa7=4.27551e-06 sody=5.1922e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.3e-07 spomb=1.24e-06
+ spomb1=1.3629e-08 _ccoflag=0 _rcoflag=0 _rgflag=0
XMpcap<0>__10 Mpcap<0>__10:d Mpcap<0>__10:g Mpcap<0>__10:s Mpcap<1>:b pch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.120978
+ NRS=0.120978 sa=1.0175e-05 sb=2.335e-06 sca=11.0003 scb=0.00839396
+ scc=0.00121277 sa1=1.0175e-05 sb1=2.335e-06 sa2=1.0175e-05 sb2=2.335e-06
+ sa3=1.0175e-05 sb3=2.335e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=3.81985e-07 sa4=3.79878e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.52118e-06 enx=5e-06 enx1=5e-06 eny=4.40961e-06
+ eny1=4.33709e-06 eny2=4.39778e-06 rex=3.16263e-06 rey=3.30763e-06
+ sodxa=2.915e-06 sodxb=1.205e-06 sodx=1.78567e-06 sodx1=2.78916e-06
+ sodx2=5.0041e-06 sodx4=2.58505e-06 sa5=3.84122e-06 sa6=2.93522e-06
+ sa7=2.93043e-06 sody=5.1922e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.3e-07 spomb=1.24e-06
+ spomb1=1.3629e-08 _ccoflag=0 _rcoflag=0 _rgflag=0
XMpcap<0>__11 Mpcap<0>__11:d Mpcap<0>__11:g Mpcap<0>__11:s Mpcap<1>:b pch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.120978
+ NRS=0.120978 sa=1.1295e-05 sb=1.215e-06 sca=11.2563 scb=0.00839496
+ scc=0.00121277 sa1=1.1295e-05 sb1=1.215e-06 sa2=1.1295e-05 sb2=1.215e-06
+ sa3=1.1295e-05 sb3=1.215e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=3.17891e-07 sa4=2.18901e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.32542e-06 enx=4.45442e-06 enx1=4.43209e-06
+ eny=4.40961e-06 eny1=4.33709e-06 eny2=4.39778e-06 rex=3.30453e-06
+ rey=3.30763e-06 sodxa=3.21e-06 sodxb=1.205e-06 sodx=1.8533e-06
+ sodx1=1.94522e-06 sodx2=2.91622e-06 sodx4=1.48016e-06 sa5=2.25832e-06
+ sa6=1.5493e-06 sa7=1.5304e-06 sody=5.1922e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.3e-07 spomb=1.24e-06
+ spomb1=1.3629e-08 _ccoflag=0 _rcoflag=0 _rgflag=0
XMpcap<0>__12 Mpcap<0>__12:d Mpcap<0>__12:g Mpcap<0>__12:s Mpcap<1>:b pch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=9.5e-14 PD=1.12e-06 PS=2.19e-06 NRD=0.120978
+ NRS=0.111164 sa=1.2415e-05 sb=9.5e-08 sca=15.9972 scb=0.0135339 scc=0.00156191
+ sa1=1.2415e-05 sb1=9.5e-08 sa2=1.2415e-05 sb2=9.5e-08 sa3=1.2415e-05
+ sb3=9.5e-08 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07 spa3=1.2e-07
+ sap=1.40863e-07 sa4=1.89446e-07 spba=1.96927e-07 spba1=2.57596e-07
+ sapb=1.52447e-07 enx=3.75443e-06 enx1=3.63876e-06 eny=4.40961e-06
+ eny1=4.33709e-06 eny2=4.39778e-06 rex=3.29331e-06 rey=3.30763e-06 sodxa=4e-06
+ sodxb=1.205e-06 sodx=2.00919e-06 sodx1=5.85442e-07 sodx2=1.37267e-06
+ sodx4=1.6814e-07 sa5=2.93604e-07 sa6=5.17837e-07 sa7=1.19981e-07
+ sody=5.1922e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0 spmt=1.11111e+15 spomt=0
+ spomt1=1.11111e+60 spmb=1.3e-07 spomb=1.24e-06 spomb1=1.3629e-08 _ccoflag=0
+ _rcoflag=0 _rgflag=0
XMncap<1> Mncap<1>:d Mncap<1>:g Mncap<1>:s Mncap<1>:b nch_mac L=1e-06 W=1e-06
+ AD=9.5e-14 AS=6e-14 PD=2.19e-06 PS=1.12e-06 NRD=0.282973 NRS=0.371123
+ sa=9.5e-08 sb=1.2415e-05 sca=0.820334 scb=7.45123e-06 scc=2.23184e-10
+ sa1=9.5e-08 sb1=1.2415e-05 sa2=9.5e-08 sb2=1.2415e-05 sa3=9.5e-08
+ sb3=1.2415e-05 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07 spa3=1.2e-07
+ sap=1.40863e-07 sa4=1.89446e-07 spba=1.96927e-07 spba1=2.57596e-07
+ sapb=1.52447e-07 enx=5e-06 enx1=5e-06 eny=3.76745e-06 eny1=3.5023e-06
+ eny2=3.71472e-06 rex=3.16263e-06 rey=3.30042e-06 sodxa=2.915e-06
+ sodxb=2.62e-06 sodx=2.7616e-06 sodx1=7.8107e-07 sodx2=1.55728e-06
+ sodx4=1.90756e-07 sa5=2.93604e-07 sa6=5.17837e-07 sa7=1.19981e-07
+ sody=5.13319e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0 spmt=1.11111e+15 spomt=0
+ spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0 spomb1=1.11111e+60 _ccoflag=0
+ _rcoflag=0 _rgflag=0
XMncap<1>__2 Mncap<1>__2:d Mncap<1>__2:g Mncap<1>__2:s Mncap<1>:b nch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.371123
+ NRS=0.371123 sa=1.215e-06 sb=1.1295e-05 sca=0.77385 scb=7.45123e-06
+ scc=2.23184e-10 sa1=1.215e-06 sb1=1.1295e-05 sa2=1.215e-06 sb2=1.1295e-05
+ sa3=1.215e-06 sb3=1.1295e-05 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=3.17891e-07 sa4=2.18901e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.32542e-06 enx=5e-06 enx1=5e-06 eny=3.76745e-06
+ eny1=3.5023e-06 eny2=3.71472e-06 rex=3.16263e-06 rey=3.30042e-06
+ sodxa=2.915e-06 sodxb=1.5e-06 sodx=2.03441e-06 sodx1=2.47017e-06
+ sodx2=3.30741e-06 sodx4=1.67875e-06 sa5=2.25832e-06 sa6=1.5493e-06
+ sa7=1.5304e-06 sody=5.13319e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMncap<1>__3 Mncap<1>__3:d Mncap<1>__3:g Mncap<1>__3:s Mncap<1>:b nch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.371123
+ NRS=0.371123 sa=2.335e-06 sb=1.0175e-05 sca=0.75232 scb=7.45123e-06
+ scc=2.23184e-10 sa1=2.335e-06 sb1=1.0175e-05 sa2=2.335e-06 sb2=1.0175e-05
+ sa3=2.335e-06 sb3=1.0175e-05 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=3.81985e-07 sa4=3.79878e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.52118e-06 enx=5e-06 enx1=5e-06 eny=3.76745e-06
+ eny1=3.5023e-06 eny2=3.71472e-06 rex=3.16263e-06 rey=3.30042e-06
+ sodxa=2.915e-06 sodxb=1.205e-06 sodx=1.78567e-06 sodx1=3.33757e-06
+ sodx2=5.65938e-06 sodx4=2.92364e-06 sa5=3.84122e-06 sa6=2.93522e-06
+ sa7=2.93043e-06 sody=5.13319e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMncap<1>__4 Mncap<1>__4:d Mncap<1>__4:g Mncap<1>__4:s Mncap<1>:b nch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.371123
+ NRS=0.371123 sa=3.455e-06 sb=9.055e-06 sca=0.747648 scb=7.45123e-06
+ scc=2.23184e-10 sa1=3.455e-06 sb1=9.055e-06 sa2=3.455e-06 sb2=9.055e-06
+ sa3=3.455e-06 sb3=9.055e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=4.18663e-07 sa4=5.00183e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.62946e-06 enx=5e-06 enx1=5e-06 eny=3.76745e-06
+ eny1=3.5023e-06 eny2=3.71472e-06 rex=3.16263e-06 rey=3.30042e-06
+ sodxa=2.915e-06 sodxb=1.205e-06 sodx=1.78567e-06 sodx1=3.86094e-06
+ sodx2=7.75756e-06 sodx4=4.01554e-06 sa5=5.02348e-06 sa6=4.27729e-06
+ sa7=4.27551e-06 sody=5.13319e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMncap<1>__5 Mncap<1>__5:d Mncap<1>__5:g Mncap<1>__5:s Mncap<1>:b nch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.371123
+ NRS=0.371123 sa=4.575e-06 sb=7.935e-06 sca=0.747648 scb=7.45123e-06
+ scc=2.23184e-10 sa1=4.575e-06 sb1=7.935e-06 sa2=4.575e-06 sb2=7.935e-06
+ sa3=4.575e-06 sb3=7.935e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=4.39936e-07 sa4=5.80386e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.69117e-06 enx=5e-06 enx1=5e-06 eny=3.76745e-06
+ eny1=3.5023e-06 eny2=3.71472e-06 rex=3.16263e-06 rey=3.30042e-06
+ sodxa=2.915e-06 sodxb=1.205e-06 sodx=1.78567e-06 sodx1=4.13095e-06
+ sodx2=9.3739e-06 sodx4=4.85448e-06 sa5=5.81165e-06 sa6=5.4376e-06
+ sa7=5.43701e-06 sody=5.13319e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMncap<1>__6 Mncap<1>__6:d Mncap<1>__6:g Mncap<1>__6:s Mncap<1>:b nch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.371123
+ NRS=0.371123 sa=5.695e-06 sb=6.815e-06 sca=0.747648 scb=7.45123e-06
+ scc=2.23184e-10 sa1=5.695e-06 sb1=6.815e-06 sa2=5.695e-06 sb2=6.815e-06
+ sa3=5.695e-06 sb3=6.815e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=4.49842e-07 sa4=6.20487e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.71965e-06 enx=5e-06 enx1=5e-06 eny=3.76745e-06
+ eny1=3.5023e-06 eny2=3.71472e-06 rex=3.16263e-06 rey=3.30042e-06
+ sodxa=2.915e-06 sodxb=1.205e-06 sodx=1.78567e-06 sodx1=4.19942e-06
+ sodx2=1.01297e-05 sodx4=5.24659e-06 sa5=6.20574e-06 sa6=6.156e-06
+ sa7=6.15593e-06 sody=5.13319e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMncap<1>__7 Mncap<1>__7:d Mncap<1>__7:g Mncap<1>__7:s Mncap<1>:b nch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.371123
+ NRS=0.371123 sa=6.815e-06 sb=5.695e-06 sca=0.747648 scb=7.45123e-06
+ scc=2.23184e-10 sa1=6.815e-06 sb1=5.695e-06 sa2=6.815e-06 sb2=5.695e-06
+ sa3=6.815e-06 sb3=5.695e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=4.49842e-07 sa4=6.20487e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.71965e-06 enx=5e-06 enx1=5e-06 eny=3.76745e-06
+ eny1=3.5023e-06 eny2=3.71472e-06 rex=3.16263e-06 rey=3.30042e-06
+ sodxa=2.915e-06 sodxb=1.205e-06 sodx=1.78567e-06 sodx1=4.09372e-06
+ sodx2=9.80409e-06 sodx4=5.07786e-06 sa5=6.20574e-06 sa6=6.156e-06
+ sa7=6.15593e-06 sody=5.13319e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMncap<1>__8 Mncap<1>__8:d Mncap<1>__8:g Mncap<1>__8:s Mncap<1>:b nch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.371123
+ NRS=0.371123 sa=7.935e-06 sb=4.575e-06 sca=0.747648 scb=7.45123e-06
+ scc=2.23184e-10 sa1=7.935e-06 sb1=4.575e-06 sa2=7.935e-06 sb2=4.575e-06
+ sa3=7.935e-06 sb3=4.575e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=4.39936e-07 sa4=5.80386e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.69117e-06 enx=5e-06 enx1=5e-06 eny=3.76745e-06
+ eny1=3.5023e-06 eny2=3.71472e-06 rex=3.16263e-06 rey=3.30042e-06
+ sodxa=2.915e-06 sodxb=1.205e-06 sodx=1.78567e-06 sodx1=3.82652e-06
+ sodx2=8.61161e-06 sodx4=4.45959e-06 sa5=5.81165e-06 sa6=5.4376e-06
+ sa7=5.43701e-06 sody=5.13319e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMncap<1>__9 Mncap<1>__9:d Mncap<1>__9:g Mncap<1>__9:s Mncap<1>:b nch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.371123
+ NRS=0.371123 sa=9.055e-06 sb=3.455e-06 sca=0.761871 scb=7.45123e-06
+ scc=2.23184e-10 sa1=9.055e-06 sb1=3.455e-06 sa2=9.055e-06 sb2=3.455e-06
+ sa3=9.055e-06 sb3=3.455e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=4.18663e-07 sa4=5.00183e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.62946e-06 enx=5e-06 enx1=5e-06 eny=3.76745e-06
+ eny1=3.5023e-06 eny2=3.71472e-06 rex=3.16263e-06 rey=3.30042e-06
+ sodxa=2.915e-06 sodxb=1.205e-06 sodx=1.78567e-06 sodx1=3.39761e-06
+ sodx2=6.93208e-06 sodx4=3.58813e-06 sa5=5.02348e-06 sa6=4.27729e-06
+ sa7=4.27551e-06 sody=5.13319e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMncap<1>__10 Mncap<1>__10:d Mncap<1>__10:g Mncap<1>__10:s Mncap<1>:b nch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.371123
+ NRS=0.371123 sa=1.0175e-05 sb=2.335e-06 sca=0.793349 scb=7.45123e-06
+ scc=2.23184e-10 sa1=1.0175e-05 sb1=2.335e-06 sa2=1.0175e-05 sb2=2.335e-06
+ sa3=1.0175e-05 sb3=2.335e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=3.81985e-07 sa4=3.79878e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.52118e-06 enx=5e-06 enx1=5e-06 eny=3.76745e-06
+ eny1=3.5023e-06 eny2=3.71472e-06 rex=3.16263e-06 rey=3.30042e-06
+ sodxa=2.915e-06 sodxb=1.205e-06 sodx=1.78567e-06 sodx1=2.78916e-06
+ sodx2=5.0041e-06 sodx4=2.58505e-06 sa5=3.84122e-06 sa6=2.93522e-06
+ sa7=2.93043e-06 sody=5.13319e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMncap<1>__11 Mncap<1>__11:d Mncap<1>__11:g Mncap<1>__11:s Mncap<1>:b nch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.371123
+ NRS=0.371123 sa=1.1295e-05 sb=1.215e-06 sca=0.870575 scb=7.45139e-06
+ scc=2.23184e-10 sa1=1.1295e-05 sb1=1.215e-06 sa2=1.1295e-05 sb2=1.215e-06
+ sa3=1.1295e-05 sb3=1.215e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=3.17891e-07 sa4=2.18901e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.32542e-06 enx=4.45442e-06 enx1=4.43209e-06
+ eny=3.76745e-06 eny1=3.5023e-06 eny2=3.71472e-06 rex=3.30453e-06
+ rey=3.30042e-06 sodxa=3.21e-06 sodxb=1.205e-06 sodx=1.8533e-06
+ sodx1=1.94522e-06 sodx2=2.91622e-06 sodx4=1.48016e-06 sa5=2.25832e-06
+ sa6=1.5493e-06 sa7=1.5304e-06 sody=5.13319e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMncap<1>__12 Mncap<1>__12:d Mncap<1>__12:g Mncap<1>__12:s Mncap<1>:b nch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=9.5e-14 PD=1.12e-06 PS=2.19e-06 NRD=0.371123
+ NRS=0.282973 sa=1.2415e-05 sb=9.5e-08 sca=1.16385 scb=9.53924e-06
+ scc=2.38772e-10 sa1=1.2415e-05 sb1=9.5e-08 sa2=1.2415e-05 sb2=9.5e-08
+ sa3=1.2415e-05 sb3=9.5e-08 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=1.40863e-07 sa4=1.89446e-07 spba=1.96927e-07
+ spba1=2.57596e-07 sapb=1.52447e-07 enx=3.75443e-06 enx1=3.63876e-06
+ eny=3.76745e-06 eny1=3.5023e-06 eny2=3.71472e-06 rex=3.29331e-06
+ rey=3.30042e-06 sodxa=4e-06 sodxb=1.205e-06 sodx=2.00919e-06 sodx1=5.85442e-07
+ sodx2=1.37267e-06 sodx4=1.6814e-07 sa5=2.93604e-07 sa6=5.17837e-07
+ sa7=1.19981e-07 sody=5.13319e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMncap<0> Mncap<0>:d Mncap<0>:g Mncap<0>:s Mncap<1>:b nch_mac L=1e-06 W=1e-06
+ AD=9.5e-14 AS=6e-14 PD=2.19e-06 PS=1.12e-06 NRD=0.282973 NRS=0.371123
+ sa=9.5e-08 sb=1.2415e-05 sca=0.673653 scb=6.27575e-07 scc=1.27552e-12
+ sa1=9.5e-08 sb1=1.2415e-05 sa2=9.5e-08 sb2=1.2415e-05 sa3=9.5e-08
+ sb3=1.2415e-05 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07 spa3=1.2e-07
+ sap=1.40863e-07 sa4=1.89446e-07 spba=1.96927e-07 spba1=2.57596e-07
+ sapb=1.52447e-07 enx=5e-06 enx1=5e-06 eny=4.59715e-06 eny1=4.56209e-06
+ eny2=4.59168e-06 rex=3.16263e-06 rey=3.28388e-06 sodxa=1.81013e-06
+ sodxb=2.62e-06 sodx=2.15923e-06 sodx1=6.68181e-07 sodx2=1.45481e-06
+ sodx4=1.78203e-07 sa5=2.93604e-07 sa6=5.17837e-07 sa7=1.19981e-07
+ sody=2.41999e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0 spmt=1.11111e+15 spomt=0
+ spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0 spomb1=1.11111e+60 _ccoflag=0
+ _rcoflag=0 _rgflag=0
XMncap<0>__2 Mncap<0>__2:d Mncap<0>__2:g Mncap<0>__2:s Mncap<1>:b nch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.371123
+ NRS=0.371123 sa=1.215e-06 sb=1.1295e-05 sca=0.627169 scb=6.27574e-07
+ scc=1.27552e-12 sa1=1.215e-06 sb1=1.1295e-05 sa2=1.215e-06 sb2=1.1295e-05
+ sa3=1.215e-06 sb3=1.1295e-05 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=3.17891e-07 sa4=2.18901e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.32542e-06 enx=5e-06 enx1=5e-06 eny=4.59715e-06
+ eny1=4.56209e-06 eny2=4.59168e-06 rex=3.16263e-06 rey=3.28388e-06
+ sodxa=1.81013e-06 sodxb=1.5e-06 sodx=1.64415e-06 sodx1=2.151e-06
+ sodx2=3.09015e-06 sodx4=1.56846e-06 sa5=2.25832e-06 sa6=1.5493e-06
+ sa7=1.5304e-06 sody=2.41999e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMncap<0>__3 Mncap<0>__3:d Mncap<0>__3:g Mncap<0>__3:s Mncap<1>:b nch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.371123
+ NRS=0.371123 sa=2.335e-06 sb=1.0175e-05 sca=0.605639 scb=6.27574e-07
+ scc=1.27552e-12 sa1=2.335e-06 sb1=1.0175e-05 sa2=2.335e-06 sb2=1.0175e-05
+ sa3=2.335e-06 sb3=1.0175e-05 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=3.81985e-07 sa4=3.79878e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.52118e-06 enx=5e-06 enx1=5e-06 eny=4.59715e-06
+ eny1=4.56209e-06 eny2=4.59168e-06 rex=3.16263e-06 rey=3.28388e-06
+ sodxa=1.81013e-06 sodxb=1.205e-06 sodx=1.46171e-06 sodx1=2.96155e-06
+ sodx2=5.29297e-06 sodx4=2.73432e-06 sa5=3.84122e-06 sa6=2.93522e-06
+ sa7=2.93043e-06 sody=2.41999e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMncap<0>__4 Mncap<0>__4:d Mncap<0>__4:g Mncap<0>__4:s Mncap<1>:b nch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.371123
+ NRS=0.371123 sa=3.455e-06 sb=9.055e-06 sca=0.600967 scb=6.27574e-07
+ scc=1.27552e-12 sa1=3.455e-06 sb1=9.055e-06 sa2=3.455e-06 sb2=9.055e-06
+ sa3=3.455e-06 sb3=9.055e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=4.18663e-07 sa4=5.00183e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.62946e-06 enx=5e-06 enx1=5e-06 eny=4.59715e-06
+ eny1=4.56209e-06 eny2=4.59168e-06 rex=3.16263e-06 rey=3.28388e-06
+ sodxa=1.81013e-06 sodxb=1.205e-06 sodx=1.46171e-06 sodx1=3.48202e-06
+ sodx2=7.28249e-06 sodx4=3.76958e-06 sa5=5.02348e-06 sa6=4.27729e-06
+ sa7=4.27551e-06 sody=2.41999e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMncap<0>__5 Mncap<0>__5:d Mncap<0>__5:g Mncap<0>__5:s Mncap<1>:b nch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.371123
+ NRS=0.371123 sa=4.575e-06 sb=7.935e-06 sca=0.600967 scb=6.27574e-07
+ scc=1.27552e-12 sa1=4.575e-06 sb1=7.935e-06 sa2=4.575e-06 sb2=7.935e-06
+ sa3=4.575e-06 sb3=7.935e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=4.39936e-07 sa4=5.80386e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.69117e-06 enx=5e-06 enx1=5e-06 eny=4.59715e-06
+ eny1=4.56209e-06 eny2=4.59168e-06 rex=3.16263e-06 rey=3.28388e-06
+ sodxa=1.81013e-06 sodxb=1.205e-06 sodx=1.46171e-06 sodx1=3.78287e-06
+ sodx2=8.88295e-06 sodx4=4.60019e-06 sa5=5.81165e-06 sa6=5.4376e-06
+ sa7=5.43701e-06 sody=2.41999e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMncap<0>__6 Mncap<0>__6:d Mncap<0>__6:g Mncap<0>__6:s Mncap<1>:b nch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.371123
+ NRS=0.371123 sa=5.695e-06 sb=6.815e-06 sca=0.600967 scb=6.27574e-07
+ scc=1.27552e-12 sa1=5.695e-06 sb1=6.815e-06 sa2=5.695e-06 sb2=6.815e-06
+ sa3=5.695e-06 sb3=6.815e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=4.49842e-07 sa4=6.20487e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.71965e-06 enx=5e-06 enx1=5e-06 eny=4.59715e-06
+ eny1=4.56209e-06 eny2=4.59168e-06 rex=3.16263e-06 rey=3.28388e-06
+ sodxa=1.81013e-06 sodxb=1.205e-06 sodx=1.46171e-06 sodx1=3.90135e-06
+ sodx2=9.7551e-06 sodx4=5.05253e-06 sa5=6.20574e-06 sa6=6.156e-06
+ sa7=6.15593e-06 sody=2.41999e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMncap<0>__7 Mncap<0>__7:d Mncap<0>__7:g Mncap<0>__7:s Mncap<1>:b nch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.371123
+ NRS=0.371123 sa=6.815e-06 sb=5.695e-06 sca=0.600967 scb=6.27574e-07
+ scc=1.27552e-12 sa1=6.815e-06 sb1=5.695e-06 sa2=6.815e-06 sb2=5.695e-06
+ sa3=6.815e-06 sb3=5.695e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=4.49842e-07 sa4=6.20487e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.71965e-06 enx=5e-06 enx1=5e-06 eny=4.59715e-06
+ eny1=4.56209e-06 eny2=4.59168e-06 rex=3.16263e-06 rey=3.28388e-06
+ sodxa=1.81013e-06 sodxb=1.205e-06 sodx=1.46171e-06 sodx1=3.85523e-06
+ sodx2=9.60765e-06 sodx4=4.97613e-06 sa5=6.20574e-06 sa6=6.156e-06
+ sa7=6.15593e-06 sody=2.41999e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMncap<0>__8 Mncap<0>__8:d Mncap<0>__8:g Mncap<0>__8:s Mncap<1>:b nch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.371123
+ NRS=0.371123 sa=7.935e-06 sb=4.575e-06 sca=0.600967 scb=6.27574e-07
+ scc=1.27552e-12 sa1=7.935e-06 sb1=4.575e-06 sa2=7.935e-06 sb2=4.575e-06
+ sa3=7.935e-06 sb3=4.575e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=4.39936e-07 sa4=5.80386e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.69117e-06 enx=5e-06 enx1=5e-06 eny=4.59715e-06
+ eny1=4.56209e-06 eny2=4.59168e-06 rex=3.16263e-06 rey=3.28388e-06
+ sodxa=1.81013e-06 sodxb=1.205e-06 sodx=1.46171e-06 sodx1=3.65028e-06
+ sodx2=8.54027e-06 sodx4=4.42267e-06 sa5=5.81165e-06 sa6=5.4376e-06
+ sa7=5.43701e-06 sody=2.41999e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMncap<0>__9 Mncap<0>__9:d Mncap<0>__9:g Mncap<0>__9:s Mncap<1>:b nch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.371123
+ NRS=0.371123 sa=9.055e-06 sb=3.455e-06 sca=0.61519 scb=6.27574e-07
+ scc=1.27552e-12 sa1=9.055e-06 sb1=3.455e-06 sa2=9.055e-06 sb2=3.455e-06
+ sa3=9.055e-06 sb3=3.455e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=4.18663e-07 sa4=5.00183e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.62946e-06 enx=5e-06 enx1=5e-06 eny=4.59715e-06
+ eny1=4.56209e-06 eny2=4.59168e-06 rex=3.16263e-06 rey=3.28388e-06
+ sodxa=1.81013e-06 sodxb=1.205e-06 sodx=1.46171e-06 sodx1=3.28091e-06
+ sodx2=6.91376e-06 sodx4=3.57867e-06 sa5=5.02348e-06 sa6=4.27729e-06
+ sa7=4.27551e-06 sody=2.41999e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMncap<0>__10 Mncap<0>__10:d Mncap<0>__10:g Mncap<0>__10:s Mncap<1>:b nch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.371123
+ NRS=0.371123 sa=1.0175e-05 sb=2.335e-06 sca=0.646667 scb=6.27574e-07
+ scc=1.27552e-12 sa1=1.0175e-05 sb1=2.335e-06 sa2=1.0175e-05 sb2=2.335e-06
+ sa3=1.0175e-05 sb3=2.335e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=3.81985e-07 sa4=3.79878e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.52118e-06 enx=5e-06 enx1=5e-06 eny=4.59715e-06
+ eny1=4.56209e-06 eny2=4.59168e-06 rex=3.16263e-06 rey=3.28388e-06
+ sodxa=1.81013e-06 sodxb=1.205e-06 sodx=1.46171e-06 sodx1=2.72473e-06
+ sodx2=5.00111e-06 sodx4=2.58351e-06 sa5=3.84122e-06 sa6=2.93522e-06
+ sa7=2.93043e-06 sody=2.41999e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMncap<0>__11 Mncap<0>__11:d Mncap<0>__11:g Mncap<0>__11:s Mncap<1>:b nch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=6e-14 PD=1.12e-06 PS=1.12e-06 NRD=0.371123
+ NRS=0.371123 sa=1.1295e-05 sb=1.215e-06 sca=0.723894 scb=6.27735e-07
+ scc=1.27552e-12 sa1=1.1295e-05 sb1=1.215e-06 sa2=1.1295e-05 sb2=1.215e-06
+ sa3=1.1295e-05 sb3=1.215e-06 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=3.17891e-07 sa4=2.18901e-06 spba=4.96387e-07
+ spba1=5.18073e-07 sapb=1.32542e-06 enx=4.45442e-06 enx1=4.43209e-06
+ eny=4.59715e-06 eny1=4.56209e-06 eny2=4.59168e-06 rex=3.30453e-06
+ rey=3.28388e-06 sodxa=2.23292e-06 sodxb=1.205e-06 sodx=1.60193e-06
+ sodx1=1.92783e-06 sodx2=2.91608e-06 sodx4=1.48009e-06 sa5=2.25832e-06
+ sa6=1.5493e-06 sa7=1.5304e-06 sody=2.41999e-07 dw1=-1.4923e-20 dw=0 dvt_dfm=0
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMncap<0>__12 Mncap<0>__12:d Mncap<0>__12:g Mncap<0>__12:s Mncap<1>:b nch_mac
+ L=1e-06 W=1e-06 AD=6e-14 AS=9.5e-14 PD=1.12e-06 PS=2.19e-06 NRD=0.371123
+ NRS=0.282973 sa=1.2415e-05 sb=9.5e-08 sca=1.01717 scb=2.71558e-06
+ scc=1.68632e-11 sa1=1.2415e-05 sb1=9.5e-08 sa2=1.2415e-05 sb2=9.5e-08
+ sa3=1.2415e-05 sb3=9.5e-08 dfm_flag=1 spa=1.2e-07 spa1=1.2e-07 spa2=1.2e-07
+ spa3=1.2e-07 sap=1.40863e-07 sa4=1.89446e-07 spba=1.96927e-07
+ spba1=2.57596e-07 sapb=1.52447e-07 enx=3.75443e-06 enx1=3.63876e-06
+ eny=4.59715e-06 eny1=4.56209e-06 eny2=4.59168e-06 rex=3.29331e-06
+ rey=3.28388e-06 sodxa=3.36216e-06 sodxb=1.205e-06 sodx=1.88596e-06
+ sodx1=5.85085e-07 sodx2=1.37266e-06 sodx4=1.6814e-07 sa5=2.93604e-07
+ sa6=5.17837e-07 sa7=1.19981e-07 sody=2.41999e-07 dw1=-1.4923e-20 dw=0
+ dvt_dfm=0 spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM14 MM14:d MM14:g MM14:s MM14:b nch_mac L=3e-08 W=2.2e-07 AD=1.65e-14
+ AS=1.1e-14 PD=5.9e-07 PS=3.2e-07 NRD=1.30437 NRS=2.26737 sa=1.245e-06
+ sb=7.5e-08 sca=1.57304 scb=2.64524e-05 scc=8.35488e-10 sa1=1.245e-06
+ sb1=7.5e-08 sa2=1.245e-06 sb2=7.5e-08 sa3=1.245e-06 sb3=7.5e-08 dfm_flag=1
+ spa=1e-07 spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.13617e-07 sa4=1.42349e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.34095e-07 enx=2.70943e-06
+ enx1=2.52643e-06 eny=4.47242e-06 eny1=4.42335e-06 eny2=4.4721e-06
+ rex=2.46041e-06 rey=2.50533e-06 sodxa=1.265e-06 sodxb=8.2e-07 sodx=1.00661e-06
+ sodx1=4.51643e-07 sodx2=1.27885e-06 sodx4=1.30291e-07 sa5=2.16192e-07
+ sa6=4.94393e-07 sa7=9.47756e-08 sody=4.32229e-07 dw1=-1.22088e-20 dw=0
+ dvt_dfm=0 spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM6 MM6:d MM6:g MM6:s MM14:b nch_mac L=3e-08 W=2.2e-07 AD=1.65e-14 AS=1.1e-14
+ PD=5.9e-07 PS=3.2e-07 NRD=1.30437 NRS=2.26737 sa=1.245e-06 sb=7.5e-08
+ sca=1.84061 scb=3.71243e-05 scc=9.40787e-10 sa1=1.245e-06 sb1=7.5e-08
+ sa2=1.245e-06 sb2=7.5e-08 sa3=1.245e-06 sb3=7.5e-08 dfm_flag=1 spa=1e-07
+ spa1=1e-07 spa2=1e-07 spa3=1e-07 sap=1.13617e-07 sa4=1.42349e-07
+ spba=1.15715e-07 spba1=1.17043e-07 sapb=1.34095e-07 enx=3.71045e-06
+ enx1=3.63876e-06 eny=4.47242e-06 eny1=4.42335e-06 eny2=4.4721e-06
+ rex=2.56331e-06 rey=2.50533e-06 sodxa=8.2e-07 sodxb=1.265e-06 sodx=1.00661e-06
+ sodx1=5.03881e-07 sodx2=1.35001e-06 sodx4=1.38611e-07 sa5=2.16192e-07
+ sa6=4.94393e-07 sa7=9.47756e-08 sody=4.32229e-07 dw1=-1.22088e-20 dw=0
+ dvt_dfm=0 spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM12<1> MM12<1>:d MM12<1>:g MM12<1>:s MM14:b nch_18_mac L=1.5e-07 W=3.2e-07
+ AD=2.88e-14 AS=4.96e-14 PD=5e-07 PS=9.5e-07 NRD=0 NRS=0 sa=1.55e-07
+ sb=1.145e-06 sca=12.5573 scb=0.0117473 scc=0.000296589 sa1=1.55e-07
+ sb1=1.145e-06 sa2=1.55e-07 sb2=1.145e-06 sa3=1.55e-07 sb3=1.145e-06
+ spa=1.8e-07 spa1=1.8e-07 spa2=1.8e-07 spa3=1.8e-07 sap=2.08113e-07
+ sa4=2.73682e-07 spba=2.42247e-07 spba1=2.48284e-07 sapb=2.82867e-07
+ enx=2.73807e-06 enx1=2.53201e-06 eny=5e-06 eny1=5e-06 eny2=5e-06
+ rex=2.55565e-06 rey=2.39818e-06 sodx=9.45719e-07 sodx1=5.37972e-07
+ sodx2=1.26556e-06 sa5=3.28069e-07 sa6=4.96382e-07 sody=3.03925e-07
+ sodx4=2.37772e-07 sa7=1.95411e-07 sodxa=7.45e-07 sodxb=1.24e-06
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM12<1>__2 MM12<1>__2:d MM12<1>__2:g MM12<1>__2:s MM14:b nch_18_mac L=1.5e-07
+ W=3.2e-07 AD=2.88e-14 AS=2.88e-14 PD=5e-07 PS=5e-07 NRD=0 NRS=0 sa=4.85e-07
+ sb=8.15e-07 sca=7.68864 scb=0.00317543 scc=1.39611e-05 sa1=4.85e-07
+ sb1=8.15e-07 sa2=4.85e-07 sb2=8.15e-07 sa3=4.85e-07 sb3=8.15e-07 spa=1.8e-07
+ spa1=1.8e-07 spa2=1.8e-07 spa3=1.8e-07 sap=2.71377e-07 sa4=6.08187e-07
+ spba=2.53673e-07 spba1=2.59374e-07 sapb=3.85645e-07 enx=3.0461e-06
+ enx1=2.88276e-06 eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.61031e-06
+ rey=2.39818e-06 sodx=9.45719e-07 sodx1=7.78224e-07 sodx2=1.41499e-06
+ sa5=6.1423e-07 sa6=6.12288e-07 sody=3.03925e-07 sodx4=6.03129e-07
+ sa7=5.73435e-07 sodxa=7.45e-07 sodxb=1.24e-06 spmt=1.11111e+15 spomt=0
+ spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0 spomb1=1.11111e+60 _ccoflag=0
+ _rcoflag=0 _rgflag=0
XMM12<1>__3 MM12<1>__3:d MM12<1>__3:g MM12<1>__3:s MM14:b nch_18_mac L=1.5e-07
+ W=3.2e-07 AD=2.88e-14 AS=2.88e-14 PD=5e-07 PS=5e-07 NRD=0 NRS=0 sa=8.15e-07
+ sb=4.85e-07 sca=7.68864 scb=0.00317543 scc=1.39611e-05 sa1=8.15e-07
+ sb1=4.85e-07 sa2=8.15e-07 sb2=4.85e-07 sa3=8.15e-07 sb3=4.85e-07 spa=1.8e-07
+ spa1=1.8e-07 spa2=1.8e-07 spa3=1.8e-07 sap=2.71377e-07 sa4=6.08187e-07
+ spba=2.53673e-07 spba1=2.59374e-07 sapb=3.85645e-07 enx=3.32764e-06
+ enx1=3.20205e-06 eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.64576e-06
+ rey=2.39818e-06 sodx=9.45719e-07 sodx1=8.07257e-07 sodx2=1.46291e-06
+ sa5=6.1423e-07 sa6=6.12288e-07 sody=3.03925e-07 sodx4=6.32304e-07
+ sa7=5.73435e-07 sodxa=7.45e-07 sodxb=1.24e-06 spmt=1.11111e+15 spomt=0
+ spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0 spomb1=1.11111e+60 _ccoflag=0
+ _rcoflag=0 _rgflag=0
XMM12<1>__4 MM12<1>__4:d MM12<1>__4:g MM12<1>__4:s MM14:b nch_18_mac L=1.5e-07
+ W=3.2e-07 AD=2.88e-14 AS=4.96e-14 PD=5e-07 PS=9.5e-07 NRD=0 NRS=0 sa=1.145e-06
+ sb=1.55e-07 sca=12.5573 scb=0.0117473 scc=0.000296589 sa1=1.145e-06
+ sb1=1.55e-07 sa2=1.145e-06 sb2=1.55e-07 sa3=1.145e-06 sb3=1.55e-07 spa=1.8e-07
+ spa1=1.8e-07 spa2=1.8e-07 spa3=1.8e-07 sap=2.08113e-07 sa4=2.73682e-07
+ spba=2.42247e-07 spba1=2.48284e-07 sapb=2.82867e-07 enx=3.58717e-06
+ enx1=3.49392e-06 eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.66635e-06
+ rey=2.39818e-06 sodx=9.45719e-07 sodx1=6.0059e-07 sodx2=1.34537e-06
+ sa5=3.28069e-07 sa6=4.96382e-07 sody=3.03925e-07 sodx4=2.55628e-07
+ sa7=1.95411e-07 sodxa=7.45e-07 sodxb=1.24e-06 spmt=1.11111e+15 spomt=0
+ spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0 spomb1=1.11111e+60 _ccoflag=0
+ _rcoflag=0 _rgflag=0
XMM12<0> MM12<0>:d MM12<0>:g MM12<0>:s MM14:b nch_18_mac L=1.5e-07 W=3.2e-07
+ AD=2.88e-14 AS=4.96e-14 PD=5e-07 PS=9.5e-07 NRD=0 NRS=0 sa=1.55e-07
+ sb=1.145e-06 sca=22.6558 scb=0.0254299 scc=0.00171477 sa1=1.55e-07
+ sb1=1.145e-06 sa2=1.55e-07 sb2=1.145e-06 sa3=1.55e-07 sb3=1.145e-06
+ spa=1.8e-07 spa1=1.8e-07 spa2=1.8e-07 spa3=1.8e-07 sap=2.08113e-07
+ sa4=2.73682e-07 spba=2.42247e-07 spba1=2.48284e-07 sapb=2.82867e-07
+ enx=2.73807e-06 enx1=2.53201e-06 eny=5e-06 eny1=5e-06 eny2=5e-06
+ rex=2.55565e-06 rey=2.39818e-06 sodx=9.45719e-07 sodx1=5.37972e-07
+ sodx2=1.26556e-06 sa5=3.28069e-07 sa6=4.96382e-07 sody=4.39403e-07
+ sodx4=2.37772e-07 sa7=1.95411e-07 sodxa=7.45e-07 sodxb=1.24e-06
+ spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0
+ spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM12<0>__2 MM12<0>__2:d MM12<0>__2:g MM12<0>__2:s MM14:b nch_18_mac L=1.5e-07
+ W=3.2e-07 AD=2.88e-14 AS=2.88e-14 PD=5e-07 PS=5e-07 NRD=0 NRS=0 sa=4.85e-07
+ sb=8.15e-07 sca=17.7871 scb=0.0168581 scc=0.00143214 sa1=4.85e-07 sb1=8.15e-07
+ sa2=4.85e-07 sb2=8.15e-07 sa3=4.85e-07 sb3=8.15e-07 spa=1.8e-07 spa1=1.8e-07
+ spa2=1.8e-07 spa3=1.8e-07 sap=2.71377e-07 sa4=6.08187e-07 spba=2.53673e-07
+ spba1=2.59374e-07 sapb=3.85645e-07 enx=3.0461e-06 enx1=2.88276e-06 eny=5e-06
+ eny1=5e-06 eny2=5e-06 rex=2.61031e-06 rey=2.39818e-06 sodx=9.45719e-07
+ sodx1=7.78224e-07 sodx2=1.41499e-06 sa5=6.1423e-07 sa6=6.12288e-07
+ sody=4.23342e-07 sodx4=6.03129e-07 sa7=5.73435e-07 sodxa=7.45e-07
+ sodxb=1.24e-06 spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15
+ spomb=0 spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM12<0>__3 MM12<0>__3:d MM12<0>__3:g MM12<0>__3:s MM14:b nch_18_mac L=1.5e-07
+ W=3.2e-07 AD=2.88e-14 AS=2.88e-14 PD=5e-07 PS=5e-07 NRD=0 NRS=0 sa=8.15e-07
+ sb=4.85e-07 sca=17.7871 scb=0.0168581 scc=0.00143214 sa1=8.15e-07 sb1=4.85e-07
+ sa2=8.15e-07 sb2=4.85e-07 sa3=8.15e-07 sb3=4.85e-07 spa=1.8e-07 spa1=1.8e-07
+ spa2=1.8e-07 spa3=1.8e-07 sap=2.71377e-07 sa4=6.08187e-07 spba=2.53673e-07
+ spba1=2.59374e-07 sapb=3.85645e-07 enx=3.32764e-06 enx1=3.20205e-06 eny=5e-06
+ eny1=5e-06 eny2=5e-06 rex=2.64576e-06 rey=2.39818e-06 sodx=9.45719e-07
+ sodx1=8.07257e-07 sodx2=1.46291e-06 sa5=6.1423e-07 sa6=6.12288e-07
+ sody=4.23342e-07 sodx4=6.32304e-07 sa7=5.73435e-07 sodxa=7.45e-07
+ sodxb=1.24e-06 spmt=1.11111e+15 spomt=0 spomt1=1.11111e+60 spmb=1.11111e+15
+ spomb=0 spomb1=1.11111e+60 _ccoflag=0 _rcoflag=0 _rgflag=0
XMM12<0>__4 MM12<0>__4:d MM12<0>__4:g MM12<0>__4:s MM14:b nch_18_mac L=1.5e-07
+ W=3.2e-07 AD=2.88e-14 AS=4.96e-14 PD=5e-07 PS=9.5e-07 NRD=0 NRS=0 sa=1.145e-06
+ sb=1.55e-07 sca=22.6558 scb=0.0254299 scc=0.00171477 sa1=1.145e-06
+ sb1=1.55e-07 sa2=1.145e-06 sb2=1.55e-07 sa3=1.145e-06 sb3=1.55e-07 spa=1.8e-07
+ spa1=1.8e-07 spa2=1.8e-07 spa3=1.8e-07 sap=2.08113e-07 sa4=2.73682e-07
+ spba=2.42247e-07 spba1=2.48284e-07 sapb=2.82867e-07 enx=3.58717e-06
+ enx1=3.49392e-06 eny=5e-06 eny1=5e-06 eny2=5e-06 rex=2.66635e-06
+ rey=2.39818e-06 sodx=9.45719e-07 sodx1=6.0059e-07 sodx2=1.34537e-06
+ sa5=3.28069e-07 sa6=4.96382e-07 sody=7.09401e-07 sodx4=2.55628e-07
+ sa7=1.95411e-07 sodxa=7.45e-07 sodxb=1.24e-06 spmt=1.11111e+15 spomt=0
+ spomt1=1.11111e+60 spmb=1.11111e+15 spomb=0 spomb1=1.11111e+60 _ccoflag=0
+ _rcoflag=0 _rgflag=0
.END
